v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {TR-1um_5_stdcell/INV_X1.sym} 130 -270 0 0 {name=x1}
C {TR-1um_5_stdcell/DFFR.sym} 360 -270 0 0 {name=x2}
C {TR-1um_5_stdcell/AND2_X1.sym} 130 -110 0 0 {name=x3}
C {TR-1um_5_stdcell/MUX2.sym} 340 -100 0 0 {name=x4}
