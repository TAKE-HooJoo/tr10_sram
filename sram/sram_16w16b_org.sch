v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 1560 -4400 1560 -4350 {lab=WL0}
N 1560 -4400 1970 -4400 {lab=WL0}
N 1970 -4400 1970 -4350 {lab=WL0}
N 1510 -4400 1560 -4400 {lab=WL0}
N 1560 -4200 1560 -4150 {lab=WL1}
N 1560 -4200 1970 -4200 {lab=WL1}
N 1970 -4200 1970 -4150 {lab=WL1}
N 1510 -4200 1560 -4200 {lab=WL1}
N 1860 -4330 1890 -4330 {lab=BL0}
N 1890 -4330 1890 -4040 {lab=BL0}
N 1860 -4130 1890 -4130 {lab=BL0}
N 1860 -4350 1910 -4350 {lab=BLB0}
N 1910 -4350 1910 -4040 {lab=BLB0}
N 1860 -4150 1910 -4150 {lab=BLB0}
N 2270 -4330 2300 -4330 {lab=BL1}
N 2300 -4330 2300 -4040 {lab=BL1}
N 2270 -4130 2300 -4130 {lab=BL1}
N 2270 -4350 2320 -4350 {lab=BLB1}
N 2320 -4350 2320 -4040 {lab=BLB1}
N 2270 -4150 2320 -4150 {lab=BLB1}
N 1860 -4110 1880 -4110 {lab=VDD}
N 1860 -4310 1880 -4310 {lab=VDD}
N 1860 -4290 1870 -4290 {lab=VSS}
N 1870 -4290 1870 -4260 {lab=VSS}
N 1860 -4090 1870 -4090 {lab=VSS}
N 1870 -4090 1870 -4060 {lab=VSS}
N 2270 -4290 2280 -4290 {lab=VSS}
N 2280 -4290 2280 -4260 {lab=VSS}
N 2270 -4090 2280 -4090 {lab=VSS}
N 2280 -4090 2280 -4060 {lab=VSS}
N 2270 -4310 2290 -4310 {lab=VDD}
N 2270 -4110 2290 -4110 {lab=VDD}
N 1390 -4740 1420 -4740 {lab=VDD}
N 1390 -4690 1420 -4690 {lab=VSS}
N 1590 -4740 1620 -4740 {lab=WL0}
N 1590 -4690 1620 -4690 {lab=WL1}
N 2440 -4400 2440 -4350 {lab=WL0}
N 2440 -4400 2850 -4400 {lab=WL0}
N 2850 -4400 2850 -4350 {lab=WL0}
N 2390 -4400 2440 -4400 {lab=WL0}
N 2440 -4200 2440 -4150 {lab=WL1}
N 2440 -4200 2850 -4200 {lab=WL1}
N 2850 -4200 2850 -4150 {lab=WL1}
N 2390 -4200 2440 -4200 {lab=WL1}
N 2740 -4330 2770 -4330 {lab=BL2}
N 2770 -4330 2770 -4040 {lab=BL2}
N 2740 -4130 2770 -4130 {lab=BL2}
N 2740 -4350 2790 -4350 {lab=BLB2}
N 2790 -4350 2790 -4040 {lab=BLB2}
N 2740 -4150 2790 -4150 {lab=BLB2}
N 3150 -4330 3180 -4330 {lab=BL3}
N 3180 -4330 3180 -4040 {lab=BL3}
N 3150 -4130 3180 -4130 {lab=BL3}
N 3150 -4350 3200 -4350 {lab=BLB3}
N 3200 -4350 3200 -4040 {lab=BLB3}
N 3150 -4150 3200 -4150 {lab=BLB3}
N 2740 -4110 2760 -4110 {lab=VDD}
N 2740 -4310 2760 -4310 {lab=VDD}
N 2740 -4290 2750 -4290 {lab=VSS}
N 2750 -4290 2750 -4260 {lab=VSS}
N 2740 -4090 2750 -4090 {lab=VSS}
N 2750 -4090 2750 -4060 {lab=VSS}
N 3150 -4290 3160 -4290 {lab=VSS}
N 3160 -4290 3160 -4260 {lab=VSS}
N 3150 -4090 3160 -4090 {lab=VSS}
N 3160 -4090 3160 -4060 {lab=VSS}
N 3150 -4310 3170 -4310 {lab=VDD}
N 3150 -4110 3170 -4110 {lab=VDD}
N 1970 -4400 2390 -4400 {lab=WL0}
N 1970 -4200 2390 -4200 {lab=WL1}
N 3360 -4400 3360 -4350 {lab=WL0}
N 3360 -4400 3770 -4400 {lab=WL0}
N 3770 -4400 3770 -4350 {lab=WL0}
N 3310 -4400 3360 -4400 {lab=WL0}
N 3360 -4200 3360 -4150 {lab=WL1}
N 3360 -4200 3770 -4200 {lab=WL1}
N 3770 -4200 3770 -4150 {lab=WL1}
N 3310 -4200 3360 -4200 {lab=WL1}
N 3660 -4330 3690 -4330 {lab=BL4}
N 3690 -4330 3690 -4040 {lab=BL4}
N 3660 -4130 3690 -4130 {lab=BL4}
N 3660 -4350 3710 -4350 {lab=BLB4}
N 3710 -4350 3710 -4040 {lab=BLB4}
N 3660 -4150 3710 -4150 {lab=BLB4}
N 4070 -4330 4100 -4330 {lab=BL5}
N 4100 -4330 4100 -4040 {lab=BL5}
N 4070 -4130 4100 -4130 {lab=BL5}
N 4070 -4350 4120 -4350 {lab=BLB5}
N 4120 -4350 4120 -4040 {lab=BLB5}
N 4070 -4150 4120 -4150 {lab=BLB5}
N 3660 -4110 3680 -4110 {lab=VDD}
N 3660 -4310 3680 -4310 {lab=VDD}
N 3660 -4290 3670 -4290 {lab=VSS}
N 3670 -4290 3670 -4260 {lab=VSS}
N 3660 -4090 3670 -4090 {lab=VSS}
N 3670 -4090 3670 -4060 {lab=VSS}
N 4070 -4290 4080 -4290 {lab=VSS}
N 4080 -4290 4080 -4260 {lab=VSS}
N 4070 -4090 4080 -4090 {lab=VSS}
N 4080 -4090 4080 -4060 {lab=VSS}
N 4070 -4310 4090 -4310 {lab=VDD}
N 4070 -4110 4090 -4110 {lab=VDD}
N 4240 -4400 4240 -4350 {lab=WL0}
N 4240 -4400 4650 -4400 {lab=WL0}
N 4650 -4400 4650 -4350 {lab=WL0}
N 4190 -4400 4240 -4400 {lab=WL0}
N 4240 -4200 4240 -4150 {lab=WL1}
N 4240 -4200 4650 -4200 {lab=WL1}
N 4650 -4200 4650 -4150 {lab=WL1}
N 4190 -4200 4240 -4200 {lab=WL1}
N 4540 -4330 4570 -4330 {lab=BL6}
N 4570 -4330 4570 -4040 {lab=BL6}
N 4540 -4130 4570 -4130 {lab=BL6}
N 4540 -4350 4590 -4350 {lab=BLB6}
N 4590 -4350 4590 -4040 {lab=BLB6}
N 4540 -4150 4590 -4150 {lab=BLB6}
N 4950 -4330 4980 -4330 {lab=BL7}
N 4980 -4330 4980 -4040 {lab=BL7}
N 4950 -4130 4980 -4130 {lab=BL7}
N 4950 -4350 5000 -4350 {lab=BLB7}
N 5000 -4350 5000 -4040 {lab=BLB7}
N 4950 -4150 5000 -4150 {lab=BLB7}
N 4540 -4110 4560 -4110 {lab=VDD}
N 4540 -4310 4560 -4310 {lab=VDD}
N 4540 -4290 4550 -4290 {lab=VSS}
N 4550 -4290 4550 -4260 {lab=VSS}
N 4540 -4090 4550 -4090 {lab=VSS}
N 4550 -4090 4550 -4060 {lab=VSS}
N 4950 -4290 4960 -4290 {lab=VSS}
N 4960 -4290 4960 -4260 {lab=VSS}
N 4950 -4090 4960 -4090 {lab=VSS}
N 4960 -4090 4960 -4060 {lab=VSS}
N 4950 -4310 4970 -4310 {lab=VDD}
N 4950 -4110 4970 -4110 {lab=VDD}
N 3770 -4400 4190 -4400 {lab=WL0}
N 3770 -4200 4190 -4200 {lab=WL1}
N 2850 -4400 3310 -4400 {lab=WL0}
N 2850 -4200 3310 -4200 {lab=WL1}
N 5170 -4400 5170 -4350 {lab=#net1}
N 5170 -4400 5580 -4400 {lab=#net1}
N 5580 -4400 5580 -4350 {lab=#net1}
N 5120 -4400 5170 -4400 {lab=#net1}
N 5170 -4200 5170 -4150 {lab=#net2}
N 5170 -4200 5580 -4200 {lab=#net2}
N 5580 -4200 5580 -4150 {lab=#net2}
N 5120 -4200 5170 -4200 {lab=#net2}
N 5470 -4330 5500 -4330 {lab=BL8}
N 5500 -4330 5500 -4040 {lab=BL8}
N 5470 -4130 5500 -4130 {lab=BL8}
N 5470 -4350 5520 -4350 {lab=BLB8}
N 5520 -4350 5520 -4040 {lab=BLB8}
N 5470 -4150 5520 -4150 {lab=BLB8}
N 5880 -4330 5910 -4330 {lab=BL9}
N 5910 -4330 5910 -4040 {lab=BL9}
N 5880 -4130 5910 -4130 {lab=BL9}
N 5880 -4350 5930 -4350 {lab=BLB9}
N 5930 -4350 5930 -4040 {lab=BLB9}
N 5880 -4150 5930 -4150 {lab=BLB9}
N 5470 -4110 5490 -4110 {lab=VDD}
N 5470 -4310 5490 -4310 {lab=VDD}
N 5470 -4290 5480 -4290 {lab=VSS}
N 5480 -4290 5480 -4260 {lab=VSS}
N 5470 -4090 5480 -4090 {lab=VSS}
N 5480 -4090 5480 -4060 {lab=VSS}
N 5880 -4290 5890 -4290 {lab=VSS}
N 5890 -4290 5890 -4260 {lab=VSS}
N 5880 -4090 5890 -4090 {lab=VSS}
N 5890 -4090 5890 -4060 {lab=VSS}
N 5880 -4310 5900 -4310 {lab=VDD}
N 5880 -4110 5900 -4110 {lab=VDD}
N 6050 -4400 6050 -4350 {lab=#net1}
N 6050 -4400 6460 -4400 {lab=#net1}
N 6460 -4400 6460 -4350 {lab=#net1}
N 6000 -4400 6050 -4400 {lab=#net1}
N 6050 -4200 6050 -4150 {lab=#net2}
N 6050 -4200 6460 -4200 {lab=#net2}
N 6460 -4200 6460 -4150 {lab=#net2}
N 6000 -4200 6050 -4200 {lab=#net2}
N 6350 -4330 6380 -4330 {lab=BL10}
N 6380 -4330 6380 -4040 {lab=BL10}
N 6350 -4130 6380 -4130 {lab=BL10}
N 6350 -4350 6400 -4350 {lab=BLB10}
N 6400 -4350 6400 -4040 {lab=BLB10}
N 6350 -4150 6400 -4150 {lab=BLB10}
N 6760 -4330 6790 -4330 {lab=BL11}
N 6790 -4330 6790 -4040 {lab=BL11}
N 6760 -4130 6790 -4130 {lab=BL11}
N 6760 -4350 6810 -4350 {lab=BLB11}
N 6810 -4350 6810 -4040 {lab=BLB11}
N 6760 -4150 6810 -4150 {lab=BLB11}
N 6350 -4110 6370 -4110 {lab=VDD}
N 6350 -4310 6370 -4310 {lab=VDD}
N 6350 -4290 6360 -4290 {lab=VSS}
N 6360 -4290 6360 -4260 {lab=VSS}
N 6350 -4090 6360 -4090 {lab=VSS}
N 6360 -4090 6360 -4060 {lab=VSS}
N 6760 -4290 6770 -4290 {lab=VSS}
N 6770 -4290 6770 -4260 {lab=VSS}
N 6760 -4090 6770 -4090 {lab=VSS}
N 6770 -4090 6770 -4060 {lab=VSS}
N 6760 -4310 6780 -4310 {lab=VDD}
N 6760 -4110 6780 -4110 {lab=VDD}
N 5580 -4400 6000 -4400 {lab=#net1}
N 5580 -4200 6000 -4200 {lab=#net2}
N 6970 -4400 6970 -4350 {lab=#net1}
N 6970 -4400 7380 -4400 {lab=#net1}
N 7380 -4400 7380 -4350 {lab=#net1}
N 6920 -4400 6970 -4400 {lab=#net1}
N 6970 -4200 6970 -4150 {lab=#net2}
N 6970 -4200 7380 -4200 {lab=#net2}
N 7380 -4200 7380 -4150 {lab=#net2}
N 6920 -4200 6970 -4200 {lab=#net2}
N 7270 -4330 7300 -4330 {lab=BL12}
N 7300 -4330 7300 -4040 {lab=BL12}
N 7270 -4130 7300 -4130 {lab=BL12}
N 7270 -4350 7320 -4350 {lab=BLB12}
N 7320 -4350 7320 -4040 {lab=BLB12}
N 7270 -4150 7320 -4150 {lab=BLB12}
N 7680 -4330 7710 -4330 {lab=BL13}
N 7710 -4330 7710 -4040 {lab=BL13}
N 7680 -4130 7710 -4130 {lab=BL13}
N 7680 -4350 7730 -4350 {lab=BLB13}
N 7730 -4350 7730 -4040 {lab=BLB13}
N 7680 -4150 7730 -4150 {lab=BLB13}
N 7270 -4110 7290 -4110 {lab=VDD}
N 7270 -4310 7290 -4310 {lab=VDD}
N 7270 -4290 7280 -4290 {lab=VSS}
N 7280 -4290 7280 -4260 {lab=VSS}
N 7270 -4090 7280 -4090 {lab=VSS}
N 7280 -4090 7280 -4060 {lab=VSS}
N 7680 -4290 7690 -4290 {lab=VSS}
N 7690 -4290 7690 -4260 {lab=VSS}
N 7680 -4090 7690 -4090 {lab=VSS}
N 7690 -4090 7690 -4060 {lab=VSS}
N 7680 -4310 7700 -4310 {lab=VDD}
N 7680 -4110 7700 -4110 {lab=VDD}
N 7850 -4400 7850 -4350 {lab=#net1}
N 7850 -4400 8260 -4400 {lab=#net1}
N 8260 -4400 8260 -4350 {lab=#net1}
N 7800 -4400 7850 -4400 {lab=#net1}
N 7850 -4200 7850 -4150 {lab=#net2}
N 7850 -4200 8260 -4200 {lab=#net2}
N 8260 -4200 8260 -4150 {lab=#net2}
N 7800 -4200 7850 -4200 {lab=#net2}
N 8150 -4330 8180 -4330 {lab=BL14}
N 8180 -4330 8180 -4040 {lab=BL14}
N 8150 -4130 8180 -4130 {lab=BL14}
N 8150 -4350 8200 -4350 {lab=BLB14}
N 8200 -4350 8200 -4040 {lab=BLB14}
N 8150 -4150 8200 -4150 {lab=BLB14}
N 8560 -4330 8590 -4330 {lab=BL15}
N 8590 -4330 8590 -4040 {lab=BL15}
N 8560 -4130 8590 -4130 {lab=BL15}
N 8560 -4350 8610 -4350 {lab=BLB15}
N 8610 -4350 8610 -4040 {lab=BLB15}
N 8560 -4150 8610 -4150 {lab=BLB15}
N 8150 -4110 8170 -4110 {lab=VDD}
N 8150 -4310 8170 -4310 {lab=VDD}
N 8150 -4290 8160 -4290 {lab=VSS}
N 8160 -4290 8160 -4260 {lab=VSS}
N 8150 -4090 8160 -4090 {lab=VSS}
N 8160 -4090 8160 -4060 {lab=VSS}
N 8560 -4290 8570 -4290 {lab=VSS}
N 8570 -4290 8570 -4260 {lab=VSS}
N 8560 -4090 8570 -4090 {lab=VSS}
N 8570 -4090 8570 -4060 {lab=VSS}
N 8560 -4310 8580 -4310 {lab=VDD}
N 8560 -4110 8580 -4110 {lab=VDD}
N 7380 -4400 7800 -4400 {lab=#net1}
N 7380 -4200 7800 -4200 {lab=#net2}
N 6460 -4400 6920 -4400 {lab=#net1}
N 6460 -4200 6920 -4200 {lab=#net2}
N 4650 -4400 5120 -4400 {lab=WL0}
N 4650 -4200 5120 -4200 {lab=WL1}
N 1570 -3910 1570 -3860 {lab=WL0}
N 1570 -3910 1980 -3910 {lab=WL0}
N 1980 -3910 1980 -3860 {lab=WL0}
N 1520 -3910 1570 -3910 {lab=WL0}
N 1570 -3710 1570 -3660 {lab=WL1}
N 1570 -3710 1980 -3710 {lab=WL1}
N 1980 -3710 1980 -3660 {lab=WL1}
N 1520 -3710 1570 -3710 {lab=WL1}
N 1870 -3840 1900 -3840 {lab=BL0}
N 1900 -3840 1900 -3550 {lab=BL0}
N 1870 -3640 1900 -3640 {lab=BL0}
N 1870 -3860 1920 -3860 {lab=BLB0}
N 1920 -3860 1920 -3550 {lab=BLB0}
N 1870 -3660 1920 -3660 {lab=BLB0}
N 2280 -3840 2310 -3840 {lab=BL1}
N 2310 -3840 2310 -3550 {lab=BL1}
N 2280 -3640 2310 -3640 {lab=BL1}
N 2280 -3860 2330 -3860 {lab=BLB1}
N 2330 -3860 2330 -3550 {lab=BLB1}
N 2280 -3660 2330 -3660 {lab=BLB1}
N 1870 -3620 1890 -3620 {lab=VDD}
N 1870 -3820 1890 -3820 {lab=VDD}
N 1870 -3800 1880 -3800 {lab=VSS}
N 1880 -3800 1880 -3770 {lab=VSS}
N 1870 -3600 1880 -3600 {lab=VSS}
N 1880 -3600 1880 -3570 {lab=VSS}
N 2280 -3800 2290 -3800 {lab=VSS}
N 2290 -3800 2290 -3770 {lab=VSS}
N 2280 -3600 2290 -3600 {lab=VSS}
N 2290 -3600 2290 -3570 {lab=VSS}
N 2280 -3820 2300 -3820 {lab=VDD}
N 2280 -3620 2300 -3620 {lab=VDD}
N 2450 -3910 2450 -3860 {lab=WL0}
N 2450 -3910 2860 -3910 {lab=WL0}
N 2860 -3910 2860 -3860 {lab=WL0}
N 2400 -3910 2450 -3910 {lab=WL0}
N 2450 -3710 2450 -3660 {lab=WL1}
N 2450 -3710 2860 -3710 {lab=WL1}
N 2860 -3710 2860 -3660 {lab=WL1}
N 2400 -3710 2450 -3710 {lab=WL1}
N 2750 -3840 2780 -3840 {lab=BL2}
N 2780 -3840 2780 -3550 {lab=BL2}
N 2750 -3640 2780 -3640 {lab=BL2}
N 2750 -3860 2800 -3860 {lab=BLB2}
N 2800 -3860 2800 -3550 {lab=BLB2}
N 2750 -3660 2800 -3660 {lab=BLB2}
N 3160 -3840 3190 -3840 {lab=BL3}
N 3190 -3840 3190 -3550 {lab=BL3}
N 3160 -3640 3190 -3640 {lab=BL3}
N 3160 -3860 3210 -3860 {lab=BLB3}
N 3210 -3860 3210 -3550 {lab=BLB3}
N 3160 -3660 3210 -3660 {lab=BLB3}
N 2750 -3620 2770 -3620 {lab=VDD}
N 2750 -3820 2770 -3820 {lab=VDD}
N 2750 -3800 2760 -3800 {lab=VSS}
N 2760 -3800 2760 -3770 {lab=VSS}
N 2750 -3600 2760 -3600 {lab=VSS}
N 2760 -3600 2760 -3570 {lab=VSS}
N 3160 -3800 3170 -3800 {lab=VSS}
N 3170 -3800 3170 -3770 {lab=VSS}
N 3160 -3600 3170 -3600 {lab=VSS}
N 3170 -3600 3170 -3570 {lab=VSS}
N 3160 -3820 3180 -3820 {lab=VDD}
N 3160 -3620 3180 -3620 {lab=VDD}
N 1980 -3910 2400 -3910 {lab=WL0}
N 1980 -3710 2400 -3710 {lab=WL1}
N 3370 -3910 3370 -3860 {lab=WL0}
N 3370 -3910 3780 -3910 {lab=WL0}
N 3780 -3910 3780 -3860 {lab=WL0}
N 3320 -3910 3370 -3910 {lab=WL0}
N 3370 -3710 3370 -3660 {lab=WL1}
N 3370 -3710 3780 -3710 {lab=WL1}
N 3780 -3710 3780 -3660 {lab=WL1}
N 3320 -3710 3370 -3710 {lab=WL1}
N 3670 -3840 3700 -3840 {lab=BL4}
N 3700 -3840 3700 -3550 {lab=BL4}
N 3670 -3640 3700 -3640 {lab=BL4}
N 3670 -3860 3720 -3860 {lab=BLB4}
N 3720 -3860 3720 -3550 {lab=BLB4}
N 3670 -3660 3720 -3660 {lab=BLB4}
N 4080 -3840 4110 -3840 {lab=BL5}
N 4110 -3840 4110 -3550 {lab=BL5}
N 4080 -3640 4110 -3640 {lab=BL5}
N 4080 -3860 4130 -3860 {lab=BLB5}
N 4130 -3860 4130 -3550 {lab=BLB5}
N 4080 -3660 4130 -3660 {lab=BLB5}
N 3670 -3620 3690 -3620 {lab=VDD}
N 3670 -3820 3690 -3820 {lab=VDD}
N 3670 -3800 3680 -3800 {lab=VSS}
N 3680 -3800 3680 -3770 {lab=VSS}
N 3670 -3600 3680 -3600 {lab=VSS}
N 3680 -3600 3680 -3570 {lab=VSS}
N 4080 -3800 4090 -3800 {lab=VSS}
N 4090 -3800 4090 -3770 {lab=VSS}
N 4080 -3600 4090 -3600 {lab=VSS}
N 4090 -3600 4090 -3570 {lab=VSS}
N 4080 -3820 4100 -3820 {lab=VDD}
N 4080 -3620 4100 -3620 {lab=VDD}
N 4250 -3910 4250 -3860 {lab=WL0}
N 4250 -3910 4660 -3910 {lab=WL0}
N 4660 -3910 4660 -3860 {lab=WL0}
N 4200 -3910 4250 -3910 {lab=WL0}
N 4250 -3710 4250 -3660 {lab=WL1}
N 4250 -3710 4660 -3710 {lab=WL1}
N 4660 -3710 4660 -3660 {lab=WL1}
N 4200 -3710 4250 -3710 {lab=WL1}
N 4550 -3840 4580 -3840 {lab=BL6}
N 4580 -3840 4580 -3550 {lab=BL6}
N 4550 -3640 4580 -3640 {lab=BL6}
N 4550 -3860 4600 -3860 {lab=BLB6}
N 4600 -3860 4600 -3550 {lab=BLB6}
N 4550 -3660 4600 -3660 {lab=BLB6}
N 4960 -3840 4990 -3840 {lab=BL7}
N 4990 -3840 4990 -3550 {lab=BL7}
N 4960 -3640 4990 -3640 {lab=BL7}
N 4960 -3860 5010 -3860 {lab=BLB7}
N 5010 -3860 5010 -3550 {lab=BLB7}
N 4960 -3660 5010 -3660 {lab=BLB7}
N 4550 -3620 4570 -3620 {lab=VDD}
N 4550 -3820 4570 -3820 {lab=VDD}
N 4550 -3800 4560 -3800 {lab=VSS}
N 4560 -3800 4560 -3770 {lab=VSS}
N 4550 -3600 4560 -3600 {lab=VSS}
N 4560 -3600 4560 -3570 {lab=VSS}
N 4960 -3800 4970 -3800 {lab=VSS}
N 4970 -3800 4970 -3770 {lab=VSS}
N 4960 -3600 4970 -3600 {lab=VSS}
N 4970 -3600 4970 -3570 {lab=VSS}
N 4960 -3820 4980 -3820 {lab=VDD}
N 4960 -3620 4980 -3620 {lab=VDD}
N 3780 -3910 4200 -3910 {lab=WL0}
N 3780 -3710 4200 -3710 {lab=WL1}
N 2860 -3910 3320 -3910 {lab=WL0}
N 2860 -3710 3320 -3710 {lab=WL1}
N 5180 -3910 5180 -3860 {lab=#net1}
N 5180 -3910 5590 -3910 {lab=#net1}
N 5590 -3910 5590 -3860 {lab=#net1}
N 5130 -3910 5180 -3910 {lab=#net1}
N 5180 -3710 5180 -3660 {lab=#net2}
N 5180 -3710 5590 -3710 {lab=#net2}
N 5590 -3710 5590 -3660 {lab=#net2}
N 5130 -3710 5180 -3710 {lab=#net2}
N 5480 -3840 5510 -3840 {lab=BL8}
N 5510 -3840 5510 -3550 {lab=BL8}
N 5480 -3640 5510 -3640 {lab=BL8}
N 5480 -3860 5530 -3860 {lab=BLB8}
N 5530 -3860 5530 -3550 {lab=BLB8}
N 5480 -3660 5530 -3660 {lab=BLB8}
N 5890 -3840 5920 -3840 {lab=BL9}
N 5920 -3840 5920 -3550 {lab=BL9}
N 5890 -3640 5920 -3640 {lab=BL9}
N 5890 -3860 5940 -3860 {lab=BLB9}
N 5940 -3860 5940 -3550 {lab=BLB9}
N 5890 -3660 5940 -3660 {lab=BLB9}
N 5480 -3620 5500 -3620 {lab=VDD}
N 5480 -3820 5500 -3820 {lab=VDD}
N 5480 -3800 5490 -3800 {lab=VSS}
N 5490 -3800 5490 -3770 {lab=VSS}
N 5480 -3600 5490 -3600 {lab=VSS}
N 5490 -3600 5490 -3570 {lab=VSS}
N 5890 -3800 5900 -3800 {lab=VSS}
N 5900 -3800 5900 -3770 {lab=VSS}
N 5890 -3600 5900 -3600 {lab=VSS}
N 5900 -3600 5900 -3570 {lab=VSS}
N 5890 -3820 5910 -3820 {lab=VDD}
N 5890 -3620 5910 -3620 {lab=VDD}
N 6060 -3910 6060 -3860 {lab=#net1}
N 6060 -3910 6470 -3910 {lab=#net1}
N 6470 -3910 6470 -3860 {lab=#net1}
N 6010 -3910 6060 -3910 {lab=#net1}
N 6060 -3710 6060 -3660 {lab=#net2}
N 6060 -3710 6470 -3710 {lab=#net2}
N 6470 -3710 6470 -3660 {lab=#net2}
N 6010 -3710 6060 -3710 {lab=#net2}
N 6360 -3840 6390 -3840 {lab=BL10}
N 6390 -3840 6390 -3550 {lab=BL10}
N 6360 -3640 6390 -3640 {lab=BL10}
N 6360 -3860 6410 -3860 {lab=BLB10}
N 6410 -3860 6410 -3550 {lab=BLB10}
N 6360 -3660 6410 -3660 {lab=BLB10}
N 6770 -3840 6800 -3840 {lab=BL11}
N 6800 -3840 6800 -3550 {lab=BL11}
N 6770 -3640 6800 -3640 {lab=BL11}
N 6770 -3860 6820 -3860 {lab=BLB11}
N 6820 -3860 6820 -3550 {lab=BLB11}
N 6770 -3660 6820 -3660 {lab=BLB11}
N 6360 -3620 6380 -3620 {lab=VDD}
N 6360 -3820 6380 -3820 {lab=VDD}
N 6360 -3800 6370 -3800 {lab=VSS}
N 6370 -3800 6370 -3770 {lab=VSS}
N 6360 -3600 6370 -3600 {lab=VSS}
N 6370 -3600 6370 -3570 {lab=VSS}
N 6770 -3800 6780 -3800 {lab=VSS}
N 6780 -3800 6780 -3770 {lab=VSS}
N 6770 -3600 6780 -3600 {lab=VSS}
N 6780 -3600 6780 -3570 {lab=VSS}
N 6770 -3820 6790 -3820 {lab=VDD}
N 6770 -3620 6790 -3620 {lab=VDD}
N 5590 -3910 6010 -3910 {lab=#net1}
N 5590 -3710 6010 -3710 {lab=#net2}
N 6980 -3910 6980 -3860 {lab=#net1}
N 6980 -3910 7390 -3910 {lab=#net1}
N 7390 -3910 7390 -3860 {lab=#net1}
N 6930 -3910 6980 -3910 {lab=#net1}
N 6980 -3710 6980 -3660 {lab=#net2}
N 6980 -3710 7390 -3710 {lab=#net2}
N 7390 -3710 7390 -3660 {lab=#net2}
N 6930 -3710 6980 -3710 {lab=#net2}
N 7280 -3840 7310 -3840 {lab=BL12}
N 7310 -3840 7310 -3550 {lab=BL12}
N 7280 -3640 7310 -3640 {lab=BL12}
N 7280 -3860 7330 -3860 {lab=BLB12}
N 7330 -3860 7330 -3550 {lab=BLB12}
N 7280 -3660 7330 -3660 {lab=BLB12}
N 7690 -3840 7720 -3840 {lab=BL13}
N 7720 -3840 7720 -3550 {lab=BL13}
N 7690 -3640 7720 -3640 {lab=BL13}
N 7690 -3860 7740 -3860 {lab=BLB13}
N 7740 -3860 7740 -3550 {lab=BLB13}
N 7690 -3660 7740 -3660 {lab=BLB13}
N 7280 -3620 7300 -3620 {lab=VDD}
N 7280 -3820 7300 -3820 {lab=VDD}
N 7280 -3800 7290 -3800 {lab=VSS}
N 7290 -3800 7290 -3770 {lab=VSS}
N 7280 -3600 7290 -3600 {lab=VSS}
N 7290 -3600 7290 -3570 {lab=VSS}
N 7690 -3800 7700 -3800 {lab=VSS}
N 7700 -3800 7700 -3770 {lab=VSS}
N 7690 -3600 7700 -3600 {lab=VSS}
N 7700 -3600 7700 -3570 {lab=VSS}
N 7690 -3820 7710 -3820 {lab=VDD}
N 7690 -3620 7710 -3620 {lab=VDD}
N 7860 -3910 7860 -3860 {lab=#net1}
N 7860 -3910 8270 -3910 {lab=#net1}
N 8270 -3910 8270 -3860 {lab=#net1}
N 7810 -3910 7860 -3910 {lab=#net1}
N 7860 -3710 7860 -3660 {lab=#net2}
N 7860 -3710 8270 -3710 {lab=#net2}
N 8270 -3710 8270 -3660 {lab=#net2}
N 7810 -3710 7860 -3710 {lab=#net2}
N 8160 -3840 8190 -3840 {lab=BL14}
N 8190 -3840 8190 -3550 {lab=BL14}
N 8160 -3640 8190 -3640 {lab=BL14}
N 8160 -3860 8210 -3860 {lab=BLB14}
N 8210 -3860 8210 -3550 {lab=BLB14}
N 8160 -3660 8210 -3660 {lab=BLB14}
N 8570 -3840 8600 -3840 {lab=BL15}
N 8600 -3840 8600 -3550 {lab=BL15}
N 8570 -3640 8600 -3640 {lab=BL15}
N 8570 -3860 8620 -3860 {lab=BLB15}
N 8620 -3860 8620 -3550 {lab=BLB15}
N 8570 -3660 8620 -3660 {lab=BLB15}
N 8160 -3620 8180 -3620 {lab=VDD}
N 8160 -3820 8180 -3820 {lab=VDD}
N 8160 -3800 8170 -3800 {lab=VSS}
N 8170 -3800 8170 -3770 {lab=VSS}
N 8160 -3600 8170 -3600 {lab=VSS}
N 8170 -3600 8170 -3570 {lab=VSS}
N 8570 -3800 8580 -3800 {lab=VSS}
N 8580 -3800 8580 -3770 {lab=VSS}
N 8570 -3600 8580 -3600 {lab=VSS}
N 8580 -3600 8580 -3570 {lab=VSS}
N 8570 -3820 8590 -3820 {lab=VDD}
N 8570 -3620 8590 -3620 {lab=VDD}
N 7390 -3910 7810 -3910 {lab=#net1}
N 7390 -3710 7810 -3710 {lab=#net2}
N 6470 -3910 6930 -3910 {lab=#net1}
N 6470 -3710 6930 -3710 {lab=#net2}
N 4660 -3910 5130 -3910 {lab=WL0}
N 4660 -3710 5130 -3710 {lab=WL1}
N 1560 -3430 1560 -3380 {lab=WL0}
N 1560 -3430 1970 -3430 {lab=WL0}
N 1970 -3430 1970 -3380 {lab=WL0}
N 1510 -3430 1560 -3430 {lab=WL0}
N 1560 -3230 1560 -3180 {lab=WL1}
N 1560 -3230 1970 -3230 {lab=WL1}
N 1970 -3230 1970 -3180 {lab=WL1}
N 1510 -3230 1560 -3230 {lab=WL1}
N 1860 -3360 1890 -3360 {lab=BL0}
N 1890 -3360 1890 -3070 {lab=BL0}
N 1860 -3160 1890 -3160 {lab=BL0}
N 1860 -3380 1910 -3380 {lab=BLB0}
N 1910 -3380 1910 -3070 {lab=BLB0}
N 1860 -3180 1910 -3180 {lab=BLB0}
N 2270 -3360 2300 -3360 {lab=BL1}
N 2300 -3360 2300 -3070 {lab=BL1}
N 2270 -3160 2300 -3160 {lab=BL1}
N 2270 -3380 2320 -3380 {lab=BLB1}
N 2320 -3380 2320 -3070 {lab=BLB1}
N 2270 -3180 2320 -3180 {lab=BLB1}
N 1860 -3140 1880 -3140 {lab=VDD}
N 1860 -3340 1880 -3340 {lab=VDD}
N 1860 -3320 1870 -3320 {lab=VSS}
N 1870 -3320 1870 -3290 {lab=VSS}
N 1860 -3120 1870 -3120 {lab=VSS}
N 1870 -3120 1870 -3090 {lab=VSS}
N 2270 -3320 2280 -3320 {lab=VSS}
N 2280 -3320 2280 -3290 {lab=VSS}
N 2270 -3120 2280 -3120 {lab=VSS}
N 2280 -3120 2280 -3090 {lab=VSS}
N 2270 -3340 2290 -3340 {lab=VDD}
N 2270 -3140 2290 -3140 {lab=VDD}
N 2440 -3430 2440 -3380 {lab=WL0}
N 2440 -3430 2850 -3430 {lab=WL0}
N 2850 -3430 2850 -3380 {lab=WL0}
N 2390 -3430 2440 -3430 {lab=WL0}
N 2440 -3230 2440 -3180 {lab=WL1}
N 2440 -3230 2850 -3230 {lab=WL1}
N 2850 -3230 2850 -3180 {lab=WL1}
N 2390 -3230 2440 -3230 {lab=WL1}
N 2740 -3360 2770 -3360 {lab=BL2}
N 2770 -3360 2770 -3070 {lab=BL2}
N 2740 -3160 2770 -3160 {lab=BL2}
N 2740 -3380 2790 -3380 {lab=BLB2}
N 2790 -3380 2790 -3070 {lab=BLB2}
N 2740 -3180 2790 -3180 {lab=BLB2}
N 3150 -3360 3180 -3360 {lab=BL3}
N 3180 -3360 3180 -3070 {lab=BL3}
N 3150 -3160 3180 -3160 {lab=BL3}
N 3150 -3380 3200 -3380 {lab=BLB3}
N 3200 -3380 3200 -3070 {lab=BLB3}
N 3150 -3180 3200 -3180 {lab=BLB3}
N 2740 -3140 2760 -3140 {lab=VDD}
N 2740 -3340 2760 -3340 {lab=VDD}
N 2740 -3320 2750 -3320 {lab=VSS}
N 2750 -3320 2750 -3290 {lab=VSS}
N 2740 -3120 2750 -3120 {lab=VSS}
N 2750 -3120 2750 -3090 {lab=VSS}
N 3150 -3320 3160 -3320 {lab=VSS}
N 3160 -3320 3160 -3290 {lab=VSS}
N 3150 -3120 3160 -3120 {lab=VSS}
N 3160 -3120 3160 -3090 {lab=VSS}
N 3150 -3340 3170 -3340 {lab=VDD}
N 3150 -3140 3170 -3140 {lab=VDD}
N 1970 -3430 2390 -3430 {lab=WL0}
N 1970 -3230 2390 -3230 {lab=WL1}
N 3360 -3430 3360 -3380 {lab=WL0}
N 3360 -3430 3770 -3430 {lab=WL0}
N 3770 -3430 3770 -3380 {lab=WL0}
N 3310 -3430 3360 -3430 {lab=WL0}
N 3360 -3230 3360 -3180 {lab=WL1}
N 3360 -3230 3770 -3230 {lab=WL1}
N 3770 -3230 3770 -3180 {lab=WL1}
N 3310 -3230 3360 -3230 {lab=WL1}
N 3660 -3360 3690 -3360 {lab=BL4}
N 3690 -3360 3690 -3070 {lab=BL4}
N 3660 -3160 3690 -3160 {lab=BL4}
N 3660 -3380 3710 -3380 {lab=BLB4}
N 3710 -3380 3710 -3070 {lab=BLB4}
N 3660 -3180 3710 -3180 {lab=BLB4}
N 4070 -3360 4100 -3360 {lab=BL5}
N 4100 -3360 4100 -3070 {lab=BL5}
N 4070 -3160 4100 -3160 {lab=BL5}
N 4070 -3380 4120 -3380 {lab=BLB5}
N 4120 -3380 4120 -3070 {lab=BLB5}
N 4070 -3180 4120 -3180 {lab=BLB5}
N 3660 -3140 3680 -3140 {lab=VDD}
N 3660 -3340 3680 -3340 {lab=VDD}
N 3660 -3320 3670 -3320 {lab=VSS}
N 3670 -3320 3670 -3290 {lab=VSS}
N 3660 -3120 3670 -3120 {lab=VSS}
N 3670 -3120 3670 -3090 {lab=VSS}
N 4070 -3320 4080 -3320 {lab=VSS}
N 4080 -3320 4080 -3290 {lab=VSS}
N 4070 -3120 4080 -3120 {lab=VSS}
N 4080 -3120 4080 -3090 {lab=VSS}
N 4070 -3340 4090 -3340 {lab=VDD}
N 4070 -3140 4090 -3140 {lab=VDD}
N 4240 -3430 4240 -3380 {lab=WL0}
N 4240 -3430 4650 -3430 {lab=WL0}
N 4650 -3430 4650 -3380 {lab=WL0}
N 4190 -3430 4240 -3430 {lab=WL0}
N 4240 -3230 4240 -3180 {lab=WL1}
N 4240 -3230 4650 -3230 {lab=WL1}
N 4650 -3230 4650 -3180 {lab=WL1}
N 4190 -3230 4240 -3230 {lab=WL1}
N 4540 -3360 4570 -3360 {lab=BL6}
N 4570 -3360 4570 -3070 {lab=BL6}
N 4540 -3160 4570 -3160 {lab=BL6}
N 4540 -3380 4590 -3380 {lab=BLB6}
N 4590 -3380 4590 -3070 {lab=BLB6}
N 4540 -3180 4590 -3180 {lab=BLB6}
N 4950 -3360 4980 -3360 {lab=BL7}
N 4980 -3360 4980 -3070 {lab=BL7}
N 4950 -3160 4980 -3160 {lab=BL7}
N 4950 -3380 5000 -3380 {lab=BLB7}
N 5000 -3380 5000 -3070 {lab=BLB7}
N 4950 -3180 5000 -3180 {lab=BLB7}
N 4540 -3140 4560 -3140 {lab=VDD}
N 4540 -3340 4560 -3340 {lab=VDD}
N 4540 -3320 4550 -3320 {lab=VSS}
N 4550 -3320 4550 -3290 {lab=VSS}
N 4540 -3120 4550 -3120 {lab=VSS}
N 4550 -3120 4550 -3090 {lab=VSS}
N 4950 -3320 4960 -3320 {lab=VSS}
N 4960 -3320 4960 -3290 {lab=VSS}
N 4950 -3120 4960 -3120 {lab=VSS}
N 4960 -3120 4960 -3090 {lab=VSS}
N 4950 -3340 4970 -3340 {lab=VDD}
N 4950 -3140 4970 -3140 {lab=VDD}
N 3770 -3430 4190 -3430 {lab=WL0}
N 3770 -3230 4190 -3230 {lab=WL1}
N 2850 -3430 3310 -3430 {lab=WL0}
N 2850 -3230 3310 -3230 {lab=WL1}
N 5170 -3430 5170 -3380 {lab=#net1}
N 5170 -3430 5580 -3430 {lab=#net1}
N 5580 -3430 5580 -3380 {lab=#net1}
N 5120 -3430 5170 -3430 {lab=#net1}
N 5170 -3230 5170 -3180 {lab=#net2}
N 5170 -3230 5580 -3230 {lab=#net2}
N 5580 -3230 5580 -3180 {lab=#net2}
N 5120 -3230 5170 -3230 {lab=#net2}
N 5470 -3360 5500 -3360 {lab=BL8}
N 5500 -3360 5500 -3070 {lab=BL8}
N 5470 -3160 5500 -3160 {lab=BL8}
N 5470 -3380 5520 -3380 {lab=BLB8}
N 5520 -3380 5520 -3070 {lab=BLB8}
N 5470 -3180 5520 -3180 {lab=BLB8}
N 5880 -3360 5910 -3360 {lab=BL9}
N 5910 -3360 5910 -3070 {lab=BL9}
N 5880 -3160 5910 -3160 {lab=BL9}
N 5880 -3380 5930 -3380 {lab=BLB9}
N 5930 -3380 5930 -3070 {lab=BLB9}
N 5880 -3180 5930 -3180 {lab=BLB9}
N 5470 -3140 5490 -3140 {lab=VDD}
N 5470 -3340 5490 -3340 {lab=VDD}
N 5470 -3320 5480 -3320 {lab=VSS}
N 5480 -3320 5480 -3290 {lab=VSS}
N 5470 -3120 5480 -3120 {lab=VSS}
N 5480 -3120 5480 -3090 {lab=VSS}
N 5880 -3320 5890 -3320 {lab=VSS}
N 5890 -3320 5890 -3290 {lab=VSS}
N 5880 -3120 5890 -3120 {lab=VSS}
N 5890 -3120 5890 -3090 {lab=VSS}
N 5880 -3340 5900 -3340 {lab=VDD}
N 5880 -3140 5900 -3140 {lab=VDD}
N 6050 -3430 6050 -3380 {lab=#net1}
N 6050 -3430 6460 -3430 {lab=#net1}
N 6460 -3430 6460 -3380 {lab=#net1}
N 6000 -3430 6050 -3430 {lab=#net1}
N 6050 -3230 6050 -3180 {lab=#net2}
N 6050 -3230 6460 -3230 {lab=#net2}
N 6460 -3230 6460 -3180 {lab=#net2}
N 6000 -3230 6050 -3230 {lab=#net2}
N 6350 -3360 6380 -3360 {lab=BL10}
N 6380 -3360 6380 -3070 {lab=BL10}
N 6350 -3160 6380 -3160 {lab=BL10}
N 6350 -3380 6400 -3380 {lab=BLB10}
N 6400 -3380 6400 -3070 {lab=BLB10}
N 6350 -3180 6400 -3180 {lab=BLB10}
N 6760 -3360 6790 -3360 {lab=BL11}
N 6790 -3360 6790 -3070 {lab=BL11}
N 6760 -3160 6790 -3160 {lab=BL11}
N 6760 -3380 6810 -3380 {lab=BLB11}
N 6810 -3380 6810 -3070 {lab=BLB11}
N 6760 -3180 6810 -3180 {lab=BLB11}
N 6350 -3140 6370 -3140 {lab=VDD}
N 6350 -3340 6370 -3340 {lab=VDD}
N 6350 -3320 6360 -3320 {lab=VSS}
N 6360 -3320 6360 -3290 {lab=VSS}
N 6350 -3120 6360 -3120 {lab=VSS}
N 6360 -3120 6360 -3090 {lab=VSS}
N 6760 -3320 6770 -3320 {lab=VSS}
N 6770 -3320 6770 -3290 {lab=VSS}
N 6760 -3120 6770 -3120 {lab=VSS}
N 6770 -3120 6770 -3090 {lab=VSS}
N 6760 -3340 6780 -3340 {lab=VDD}
N 6760 -3140 6780 -3140 {lab=VDD}
N 5580 -3430 6000 -3430 {lab=#net1}
N 5580 -3230 6000 -3230 {lab=#net2}
N 6970 -3430 6970 -3380 {lab=#net1}
N 6970 -3430 7380 -3430 {lab=#net1}
N 7380 -3430 7380 -3380 {lab=#net1}
N 6920 -3430 6970 -3430 {lab=#net1}
N 6970 -3230 6970 -3180 {lab=#net2}
N 6970 -3230 7380 -3230 {lab=#net2}
N 7380 -3230 7380 -3180 {lab=#net2}
N 6920 -3230 6970 -3230 {lab=#net2}
N 7270 -3360 7300 -3360 {lab=BL12}
N 7300 -3360 7300 -3070 {lab=BL12}
N 7270 -3160 7300 -3160 {lab=BL12}
N 7270 -3380 7320 -3380 {lab=BLB12}
N 7320 -3380 7320 -3070 {lab=BLB12}
N 7270 -3180 7320 -3180 {lab=BLB12}
N 7680 -3360 7710 -3360 {lab=BL13}
N 7710 -3360 7710 -3070 {lab=BL13}
N 7680 -3160 7710 -3160 {lab=BL13}
N 7680 -3380 7730 -3380 {lab=BLB13}
N 7730 -3380 7730 -3070 {lab=BLB13}
N 7680 -3180 7730 -3180 {lab=BLB13}
N 7270 -3140 7290 -3140 {lab=VDD}
N 7270 -3340 7290 -3340 {lab=VDD}
N 7270 -3320 7280 -3320 {lab=VSS}
N 7280 -3320 7280 -3290 {lab=VSS}
N 7270 -3120 7280 -3120 {lab=VSS}
N 7280 -3120 7280 -3090 {lab=VSS}
N 7680 -3320 7690 -3320 {lab=VSS}
N 7690 -3320 7690 -3290 {lab=VSS}
N 7680 -3120 7690 -3120 {lab=VSS}
N 7690 -3120 7690 -3090 {lab=VSS}
N 7680 -3340 7700 -3340 {lab=VDD}
N 7680 -3140 7700 -3140 {lab=VDD}
N 7850 -3430 7850 -3380 {lab=#net1}
N 7850 -3430 8260 -3430 {lab=#net1}
N 8260 -3430 8260 -3380 {lab=#net1}
N 7800 -3430 7850 -3430 {lab=#net1}
N 7850 -3230 7850 -3180 {lab=#net2}
N 7850 -3230 8260 -3230 {lab=#net2}
N 8260 -3230 8260 -3180 {lab=#net2}
N 7800 -3230 7850 -3230 {lab=#net2}
N 8150 -3360 8180 -3360 {lab=BL14}
N 8180 -3360 8180 -3070 {lab=BL14}
N 8150 -3160 8180 -3160 {lab=BL14}
N 8150 -3380 8200 -3380 {lab=BLB14}
N 8200 -3380 8200 -3070 {lab=BLB14}
N 8150 -3180 8200 -3180 {lab=BLB14}
N 8560 -3360 8590 -3360 {lab=BL15}
N 8590 -3360 8590 -3070 {lab=BL15}
N 8560 -3160 8590 -3160 {lab=BL15}
N 8560 -3380 8610 -3380 {lab=BLB15}
N 8610 -3380 8610 -3070 {lab=BLB15}
N 8560 -3180 8610 -3180 {lab=BLB15}
N 8150 -3140 8170 -3140 {lab=VDD}
N 8150 -3340 8170 -3340 {lab=VDD}
N 8150 -3320 8160 -3320 {lab=VSS}
N 8160 -3320 8160 -3290 {lab=VSS}
N 8150 -3120 8160 -3120 {lab=VSS}
N 8160 -3120 8160 -3090 {lab=VSS}
N 8560 -3320 8570 -3320 {lab=VSS}
N 8570 -3320 8570 -3290 {lab=VSS}
N 8560 -3120 8570 -3120 {lab=VSS}
N 8570 -3120 8570 -3090 {lab=VSS}
N 8560 -3340 8580 -3340 {lab=VDD}
N 8560 -3140 8580 -3140 {lab=VDD}
N 7380 -3430 7800 -3430 {lab=#net1}
N 7380 -3230 7800 -3230 {lab=#net2}
N 6460 -3430 6920 -3430 {lab=#net1}
N 6460 -3230 6920 -3230 {lab=#net2}
N 4650 -3430 5120 -3430 {lab=WL0}
N 4650 -3230 5120 -3230 {lab=WL1}
N 1570 -2940 1570 -2890 {lab=WL0}
N 1570 -2940 1980 -2940 {lab=WL0}
N 1980 -2940 1980 -2890 {lab=WL0}
N 1520 -2940 1570 -2940 {lab=WL0}
N 1570 -2740 1570 -2690 {lab=WL1}
N 1570 -2740 1980 -2740 {lab=WL1}
N 1980 -2740 1980 -2690 {lab=WL1}
N 1520 -2740 1570 -2740 {lab=WL1}
N 1870 -2870 1900 -2870 {lab=BL0}
N 1900 -2870 1900 -2580 {lab=BL0}
N 1870 -2670 1900 -2670 {lab=BL0}
N 1870 -2890 1920 -2890 {lab=BLB0}
N 1920 -2890 1920 -2580 {lab=BLB0}
N 1870 -2690 1920 -2690 {lab=BLB0}
N 2280 -2870 2310 -2870 {lab=BL1}
N 2310 -2870 2310 -2580 {lab=BL1}
N 2280 -2670 2310 -2670 {lab=BL1}
N 2280 -2890 2330 -2890 {lab=BLB1}
N 2330 -2890 2330 -2580 {lab=BLB1}
N 2280 -2690 2330 -2690 {lab=BLB1}
N 1870 -2650 1890 -2650 {lab=VDD}
N 1870 -2850 1890 -2850 {lab=VDD}
N 1870 -2830 1880 -2830 {lab=VSS}
N 1880 -2830 1880 -2800 {lab=VSS}
N 1870 -2630 1880 -2630 {lab=VSS}
N 1880 -2630 1880 -2600 {lab=VSS}
N 2280 -2830 2290 -2830 {lab=VSS}
N 2290 -2830 2290 -2800 {lab=VSS}
N 2280 -2630 2290 -2630 {lab=VSS}
N 2290 -2630 2290 -2600 {lab=VSS}
N 2280 -2850 2300 -2850 {lab=VDD}
N 2280 -2650 2300 -2650 {lab=VDD}
N 2450 -2940 2450 -2890 {lab=WL0}
N 2450 -2940 2860 -2940 {lab=WL0}
N 2860 -2940 2860 -2890 {lab=WL0}
N 2400 -2940 2450 -2940 {lab=WL0}
N 2450 -2740 2450 -2690 {lab=WL1}
N 2450 -2740 2860 -2740 {lab=WL1}
N 2860 -2740 2860 -2690 {lab=WL1}
N 2400 -2740 2450 -2740 {lab=WL1}
N 2750 -2870 2780 -2870 {lab=BL2}
N 2780 -2870 2780 -2580 {lab=BL2}
N 2750 -2670 2780 -2670 {lab=BL2}
N 2750 -2890 2800 -2890 {lab=BLB2}
N 2800 -2890 2800 -2580 {lab=BLB2}
N 2750 -2690 2800 -2690 {lab=BLB2}
N 3160 -2870 3190 -2870 {lab=BL3}
N 3190 -2870 3190 -2580 {lab=BL3}
N 3160 -2670 3190 -2670 {lab=BL3}
N 3160 -2890 3210 -2890 {lab=BLB3}
N 3210 -2890 3210 -2580 {lab=BLB3}
N 3160 -2690 3210 -2690 {lab=BLB3}
N 2750 -2650 2770 -2650 {lab=VDD}
N 2750 -2850 2770 -2850 {lab=VDD}
N 2750 -2830 2760 -2830 {lab=VSS}
N 2760 -2830 2760 -2800 {lab=VSS}
N 2750 -2630 2760 -2630 {lab=VSS}
N 2760 -2630 2760 -2600 {lab=VSS}
N 3160 -2830 3170 -2830 {lab=VSS}
N 3170 -2830 3170 -2800 {lab=VSS}
N 3160 -2630 3170 -2630 {lab=VSS}
N 3170 -2630 3170 -2600 {lab=VSS}
N 3160 -2850 3180 -2850 {lab=VDD}
N 3160 -2650 3180 -2650 {lab=VDD}
N 1980 -2940 2400 -2940 {lab=WL0}
N 1980 -2740 2400 -2740 {lab=WL1}
N 3370 -2940 3370 -2890 {lab=WL0}
N 3370 -2940 3780 -2940 {lab=WL0}
N 3780 -2940 3780 -2890 {lab=WL0}
N 3320 -2940 3370 -2940 {lab=WL0}
N 3370 -2740 3370 -2690 {lab=WL1}
N 3370 -2740 3780 -2740 {lab=WL1}
N 3780 -2740 3780 -2690 {lab=WL1}
N 3320 -2740 3370 -2740 {lab=WL1}
N 3670 -2870 3700 -2870 {lab=BL4}
N 3700 -2870 3700 -2580 {lab=BL4}
N 3670 -2670 3700 -2670 {lab=BL4}
N 3670 -2890 3720 -2890 {lab=BLB4}
N 3720 -2890 3720 -2580 {lab=BLB4}
N 3670 -2690 3720 -2690 {lab=BLB4}
N 4080 -2870 4110 -2870 {lab=BL5}
N 4110 -2870 4110 -2580 {lab=BL5}
N 4080 -2670 4110 -2670 {lab=BL5}
N 4080 -2890 4130 -2890 {lab=BLB5}
N 4130 -2890 4130 -2580 {lab=BLB5}
N 4080 -2690 4130 -2690 {lab=BLB5}
N 3670 -2650 3690 -2650 {lab=VDD}
N 3670 -2850 3690 -2850 {lab=VDD}
N 3670 -2830 3680 -2830 {lab=VSS}
N 3680 -2830 3680 -2800 {lab=VSS}
N 3670 -2630 3680 -2630 {lab=VSS}
N 3680 -2630 3680 -2600 {lab=VSS}
N 4080 -2830 4090 -2830 {lab=VSS}
N 4090 -2830 4090 -2800 {lab=VSS}
N 4080 -2630 4090 -2630 {lab=VSS}
N 4090 -2630 4090 -2600 {lab=VSS}
N 4080 -2850 4100 -2850 {lab=VDD}
N 4080 -2650 4100 -2650 {lab=VDD}
N 4250 -2940 4250 -2890 {lab=WL0}
N 4250 -2940 4660 -2940 {lab=WL0}
N 4660 -2940 4660 -2890 {lab=WL0}
N 4200 -2940 4250 -2940 {lab=WL0}
N 4250 -2740 4250 -2690 {lab=WL1}
N 4250 -2740 4660 -2740 {lab=WL1}
N 4660 -2740 4660 -2690 {lab=WL1}
N 4200 -2740 4250 -2740 {lab=WL1}
N 4550 -2870 4580 -2870 {lab=BL6}
N 4580 -2870 4580 -2580 {lab=BL6}
N 4550 -2670 4580 -2670 {lab=BL6}
N 4550 -2890 4600 -2890 {lab=BLB6}
N 4600 -2890 4600 -2580 {lab=BLB6}
N 4550 -2690 4600 -2690 {lab=BLB6}
N 4960 -2870 4990 -2870 {lab=BL7}
N 4990 -2870 4990 -2580 {lab=BL7}
N 4960 -2670 4990 -2670 {lab=BL7}
N 4960 -2890 5010 -2890 {lab=BLB7}
N 5010 -2890 5010 -2580 {lab=BLB7}
N 4960 -2690 5010 -2690 {lab=BLB7}
N 4550 -2650 4570 -2650 {lab=VDD}
N 4550 -2850 4570 -2850 {lab=VDD}
N 4550 -2830 4560 -2830 {lab=VSS}
N 4560 -2830 4560 -2800 {lab=VSS}
N 4550 -2630 4560 -2630 {lab=VSS}
N 4560 -2630 4560 -2600 {lab=VSS}
N 4960 -2830 4970 -2830 {lab=VSS}
N 4970 -2830 4970 -2800 {lab=VSS}
N 4960 -2630 4970 -2630 {lab=VSS}
N 4970 -2630 4970 -2600 {lab=VSS}
N 4960 -2850 4980 -2850 {lab=VDD}
N 4960 -2650 4980 -2650 {lab=VDD}
N 3780 -2940 4200 -2940 {lab=WL0}
N 3780 -2740 4200 -2740 {lab=WL1}
N 2860 -2940 3320 -2940 {lab=WL0}
N 2860 -2740 3320 -2740 {lab=WL1}
N 5180 -2940 5180 -2890 {lab=#net1}
N 5180 -2940 5590 -2940 {lab=#net1}
N 5590 -2940 5590 -2890 {lab=#net1}
N 5130 -2940 5180 -2940 {lab=#net1}
N 5180 -2740 5180 -2690 {lab=#net2}
N 5180 -2740 5590 -2740 {lab=#net2}
N 5590 -2740 5590 -2690 {lab=#net2}
N 5130 -2740 5180 -2740 {lab=#net2}
N 5480 -2870 5510 -2870 {lab=BL8}
N 5510 -2870 5510 -2580 {lab=BL8}
N 5480 -2670 5510 -2670 {lab=BL8}
N 5480 -2890 5530 -2890 {lab=BLB8}
N 5530 -2890 5530 -2580 {lab=BLB8}
N 5480 -2690 5530 -2690 {lab=BLB8}
N 5890 -2870 5920 -2870 {lab=BL9}
N 5920 -2870 5920 -2580 {lab=BL9}
N 5890 -2670 5920 -2670 {lab=BL9}
N 5890 -2890 5940 -2890 {lab=BLB9}
N 5940 -2890 5940 -2580 {lab=BLB9}
N 5890 -2690 5940 -2690 {lab=BLB9}
N 5480 -2650 5500 -2650 {lab=VDD}
N 5480 -2850 5500 -2850 {lab=VDD}
N 5480 -2830 5490 -2830 {lab=VSS}
N 5490 -2830 5490 -2800 {lab=VSS}
N 5480 -2630 5490 -2630 {lab=VSS}
N 5490 -2630 5490 -2600 {lab=VSS}
N 5890 -2830 5900 -2830 {lab=VSS}
N 5900 -2830 5900 -2800 {lab=VSS}
N 5890 -2630 5900 -2630 {lab=VSS}
N 5900 -2630 5900 -2600 {lab=VSS}
N 5890 -2850 5910 -2850 {lab=VDD}
N 5890 -2650 5910 -2650 {lab=VDD}
N 6060 -2940 6060 -2890 {lab=#net1}
N 6060 -2940 6470 -2940 {lab=#net1}
N 6470 -2940 6470 -2890 {lab=#net1}
N 6010 -2940 6060 -2940 {lab=#net1}
N 6060 -2740 6060 -2690 {lab=#net2}
N 6060 -2740 6470 -2740 {lab=#net2}
N 6470 -2740 6470 -2690 {lab=#net2}
N 6010 -2740 6060 -2740 {lab=#net2}
N 6360 -2870 6390 -2870 {lab=BL10}
N 6390 -2870 6390 -2580 {lab=BL10}
N 6360 -2670 6390 -2670 {lab=BL10}
N 6360 -2890 6410 -2890 {lab=BLB10}
N 6410 -2890 6410 -2580 {lab=BLB10}
N 6360 -2690 6410 -2690 {lab=BLB10}
N 6770 -2870 6800 -2870 {lab=BL11}
N 6800 -2870 6800 -2580 {lab=BL11}
N 6770 -2670 6800 -2670 {lab=BL11}
N 6770 -2890 6820 -2890 {lab=BLB11}
N 6820 -2890 6820 -2580 {lab=BLB11}
N 6770 -2690 6820 -2690 {lab=BLB11}
N 6360 -2650 6380 -2650 {lab=VDD}
N 6360 -2850 6380 -2850 {lab=VDD}
N 6360 -2830 6370 -2830 {lab=VSS}
N 6370 -2830 6370 -2800 {lab=VSS}
N 6360 -2630 6370 -2630 {lab=VSS}
N 6370 -2630 6370 -2600 {lab=VSS}
N 6770 -2830 6780 -2830 {lab=VSS}
N 6780 -2830 6780 -2800 {lab=VSS}
N 6770 -2630 6780 -2630 {lab=VSS}
N 6780 -2630 6780 -2600 {lab=VSS}
N 6770 -2850 6790 -2850 {lab=VDD}
N 6770 -2650 6790 -2650 {lab=VDD}
N 5590 -2940 6010 -2940 {lab=#net1}
N 5590 -2740 6010 -2740 {lab=#net2}
N 6980 -2940 6980 -2890 {lab=#net1}
N 6980 -2940 7390 -2940 {lab=#net1}
N 7390 -2940 7390 -2890 {lab=#net1}
N 6930 -2940 6980 -2940 {lab=#net1}
N 6980 -2740 6980 -2690 {lab=#net2}
N 6980 -2740 7390 -2740 {lab=#net2}
N 7390 -2740 7390 -2690 {lab=#net2}
N 6930 -2740 6980 -2740 {lab=#net2}
N 7280 -2870 7310 -2870 {lab=BL12}
N 7310 -2870 7310 -2580 {lab=BL12}
N 7280 -2670 7310 -2670 {lab=BL12}
N 7280 -2890 7330 -2890 {lab=BLB12}
N 7330 -2890 7330 -2580 {lab=BLB12}
N 7280 -2690 7330 -2690 {lab=BLB12}
N 7690 -2870 7720 -2870 {lab=BL13}
N 7720 -2870 7720 -2580 {lab=BL13}
N 7690 -2670 7720 -2670 {lab=BL13}
N 7690 -2890 7740 -2890 {lab=BLB13}
N 7740 -2890 7740 -2580 {lab=BLB13}
N 7690 -2690 7740 -2690 {lab=BLB13}
N 7280 -2650 7300 -2650 {lab=VDD}
N 7280 -2850 7300 -2850 {lab=VDD}
N 7280 -2830 7290 -2830 {lab=VSS}
N 7290 -2830 7290 -2800 {lab=VSS}
N 7280 -2630 7290 -2630 {lab=VSS}
N 7290 -2630 7290 -2600 {lab=VSS}
N 7690 -2830 7700 -2830 {lab=VSS}
N 7700 -2830 7700 -2800 {lab=VSS}
N 7690 -2630 7700 -2630 {lab=VSS}
N 7700 -2630 7700 -2600 {lab=VSS}
N 7690 -2850 7710 -2850 {lab=VDD}
N 7690 -2650 7710 -2650 {lab=VDD}
N 7860 -2940 7860 -2890 {lab=#net1}
N 7860 -2940 8270 -2940 {lab=#net1}
N 8270 -2940 8270 -2890 {lab=#net1}
N 7810 -2940 7860 -2940 {lab=#net1}
N 7860 -2740 7860 -2690 {lab=#net2}
N 7860 -2740 8270 -2740 {lab=#net2}
N 8270 -2740 8270 -2690 {lab=#net2}
N 7810 -2740 7860 -2740 {lab=#net2}
N 8160 -2870 8190 -2870 {lab=BL14}
N 8190 -2870 8190 -2580 {lab=BL14}
N 8160 -2670 8190 -2670 {lab=BL14}
N 8160 -2890 8210 -2890 {lab=BLB14}
N 8210 -2890 8210 -2580 {lab=BLB14}
N 8160 -2690 8210 -2690 {lab=BLB14}
N 8570 -2870 8600 -2870 {lab=BL15}
N 8600 -2870 8600 -2580 {lab=BL15}
N 8570 -2670 8600 -2670 {lab=BL15}
N 8570 -2890 8620 -2890 {lab=BLB15}
N 8620 -2890 8620 -2580 {lab=BLB15}
N 8570 -2690 8620 -2690 {lab=BLB15}
N 8160 -2650 8180 -2650 {lab=VDD}
N 8160 -2850 8180 -2850 {lab=VDD}
N 8160 -2830 8170 -2830 {lab=VSS}
N 8170 -2830 8170 -2800 {lab=VSS}
N 8160 -2630 8170 -2630 {lab=VSS}
N 8170 -2630 8170 -2600 {lab=VSS}
N 8570 -2830 8580 -2830 {lab=VSS}
N 8580 -2830 8580 -2800 {lab=VSS}
N 8570 -2630 8580 -2630 {lab=VSS}
N 8580 -2630 8580 -2600 {lab=VSS}
N 8570 -2850 8590 -2850 {lab=VDD}
N 8570 -2650 8590 -2650 {lab=VDD}
N 7390 -2940 7810 -2940 {lab=#net1}
N 7390 -2740 7810 -2740 {lab=#net2}
N 6470 -2940 6930 -2940 {lab=#net1}
N 6470 -2740 6930 -2740 {lab=#net2}
N 4660 -2940 5130 -2940 {lab=WL0}
N 4660 -2740 5130 -2740 {lab=WL1}
N 1540 -2450 1540 -2400 {lab=WL0}
N 1540 -2450 1950 -2450 {lab=WL0}
N 1950 -2450 1950 -2400 {lab=WL0}
N 1490 -2450 1540 -2450 {lab=WL0}
N 1540 -2250 1540 -2200 {lab=WL1}
N 1540 -2250 1950 -2250 {lab=WL1}
N 1950 -2250 1950 -2200 {lab=WL1}
N 1490 -2250 1540 -2250 {lab=WL1}
N 1840 -2380 1870 -2380 {lab=BL0}
N 1870 -2380 1870 -2090 {lab=BL0}
N 1840 -2180 1870 -2180 {lab=BL0}
N 1840 -2400 1890 -2400 {lab=BLB0}
N 1890 -2400 1890 -2090 {lab=BLB0}
N 1840 -2200 1890 -2200 {lab=BLB0}
N 2250 -2380 2280 -2380 {lab=BL1}
N 2280 -2380 2280 -2090 {lab=BL1}
N 2250 -2180 2280 -2180 {lab=BL1}
N 2250 -2400 2300 -2400 {lab=BLB1}
N 2300 -2400 2300 -2090 {lab=BLB1}
N 2250 -2200 2300 -2200 {lab=BLB1}
N 1840 -2160 1860 -2160 {lab=VDD}
N 1840 -2360 1860 -2360 {lab=VDD}
N 1840 -2340 1850 -2340 {lab=VSS}
N 1850 -2340 1850 -2310 {lab=VSS}
N 1840 -2140 1850 -2140 {lab=VSS}
N 1850 -2140 1850 -2110 {lab=VSS}
N 2250 -2340 2260 -2340 {lab=VSS}
N 2260 -2340 2260 -2310 {lab=VSS}
N 2250 -2140 2260 -2140 {lab=VSS}
N 2260 -2140 2260 -2110 {lab=VSS}
N 2250 -2360 2270 -2360 {lab=VDD}
N 2250 -2160 2270 -2160 {lab=VDD}
N 2420 -2450 2420 -2400 {lab=WL0}
N 2420 -2450 2830 -2450 {lab=WL0}
N 2830 -2450 2830 -2400 {lab=WL0}
N 2370 -2450 2420 -2450 {lab=WL0}
N 2420 -2250 2420 -2200 {lab=WL1}
N 2420 -2250 2830 -2250 {lab=WL1}
N 2830 -2250 2830 -2200 {lab=WL1}
N 2370 -2250 2420 -2250 {lab=WL1}
N 2720 -2380 2750 -2380 {lab=BL2}
N 2750 -2380 2750 -2090 {lab=BL2}
N 2720 -2180 2750 -2180 {lab=BL2}
N 2720 -2400 2770 -2400 {lab=BLB2}
N 2770 -2400 2770 -2090 {lab=BLB2}
N 2720 -2200 2770 -2200 {lab=BLB2}
N 3130 -2380 3160 -2380 {lab=BL3}
N 3160 -2380 3160 -2090 {lab=BL3}
N 3130 -2180 3160 -2180 {lab=BL3}
N 3130 -2400 3180 -2400 {lab=BLB3}
N 3180 -2400 3180 -2090 {lab=BLB3}
N 3130 -2200 3180 -2200 {lab=BLB3}
N 2720 -2160 2740 -2160 {lab=VDD}
N 2720 -2360 2740 -2360 {lab=VDD}
N 2720 -2340 2730 -2340 {lab=VSS}
N 2730 -2340 2730 -2310 {lab=VSS}
N 2720 -2140 2730 -2140 {lab=VSS}
N 2730 -2140 2730 -2110 {lab=VSS}
N 3130 -2340 3140 -2340 {lab=VSS}
N 3140 -2340 3140 -2310 {lab=VSS}
N 3130 -2140 3140 -2140 {lab=VSS}
N 3140 -2140 3140 -2110 {lab=VSS}
N 3130 -2360 3150 -2360 {lab=VDD}
N 3130 -2160 3150 -2160 {lab=VDD}
N 1950 -2450 2370 -2450 {lab=WL0}
N 1950 -2250 2370 -2250 {lab=WL1}
N 3340 -2450 3340 -2400 {lab=WL0}
N 3340 -2450 3750 -2450 {lab=WL0}
N 3750 -2450 3750 -2400 {lab=WL0}
N 3290 -2450 3340 -2450 {lab=WL0}
N 3340 -2250 3340 -2200 {lab=WL1}
N 3340 -2250 3750 -2250 {lab=WL1}
N 3750 -2250 3750 -2200 {lab=WL1}
N 3290 -2250 3340 -2250 {lab=WL1}
N 3640 -2380 3670 -2380 {lab=BL4}
N 3670 -2380 3670 -2090 {lab=BL4}
N 3640 -2180 3670 -2180 {lab=BL4}
N 3640 -2400 3690 -2400 {lab=BLB4}
N 3690 -2400 3690 -2090 {lab=BLB4}
N 3640 -2200 3690 -2200 {lab=BLB4}
N 4050 -2380 4080 -2380 {lab=BL5}
N 4080 -2380 4080 -2090 {lab=BL5}
N 4050 -2180 4080 -2180 {lab=BL5}
N 4050 -2400 4100 -2400 {lab=BLB5}
N 4100 -2400 4100 -2090 {lab=BLB5}
N 4050 -2200 4100 -2200 {lab=BLB5}
N 3640 -2160 3660 -2160 {lab=VDD}
N 3640 -2360 3660 -2360 {lab=VDD}
N 3640 -2340 3650 -2340 {lab=VSS}
N 3650 -2340 3650 -2310 {lab=VSS}
N 3640 -2140 3650 -2140 {lab=VSS}
N 3650 -2140 3650 -2110 {lab=VSS}
N 4050 -2340 4060 -2340 {lab=VSS}
N 4060 -2340 4060 -2310 {lab=VSS}
N 4050 -2140 4060 -2140 {lab=VSS}
N 4060 -2140 4060 -2110 {lab=VSS}
N 4050 -2360 4070 -2360 {lab=VDD}
N 4050 -2160 4070 -2160 {lab=VDD}
N 4220 -2450 4220 -2400 {lab=WL0}
N 4220 -2450 4630 -2450 {lab=WL0}
N 4630 -2450 4630 -2400 {lab=WL0}
N 4170 -2450 4220 -2450 {lab=WL0}
N 4220 -2250 4220 -2200 {lab=WL1}
N 4220 -2250 4630 -2250 {lab=WL1}
N 4630 -2250 4630 -2200 {lab=WL1}
N 4170 -2250 4220 -2250 {lab=WL1}
N 4520 -2380 4550 -2380 {lab=BL6}
N 4550 -2380 4550 -2090 {lab=BL6}
N 4520 -2180 4550 -2180 {lab=BL6}
N 4520 -2400 4570 -2400 {lab=BLB6}
N 4570 -2400 4570 -2090 {lab=BLB6}
N 4520 -2200 4570 -2200 {lab=BLB6}
N 4930 -2380 4960 -2380 {lab=BL7}
N 4960 -2380 4960 -2090 {lab=BL7}
N 4930 -2180 4960 -2180 {lab=BL7}
N 4930 -2400 4980 -2400 {lab=BLB7}
N 4980 -2400 4980 -2090 {lab=BLB7}
N 4930 -2200 4980 -2200 {lab=BLB7}
N 4520 -2160 4540 -2160 {lab=VDD}
N 4520 -2360 4540 -2360 {lab=VDD}
N 4520 -2340 4530 -2340 {lab=VSS}
N 4530 -2340 4530 -2310 {lab=VSS}
N 4520 -2140 4530 -2140 {lab=VSS}
N 4530 -2140 4530 -2110 {lab=VSS}
N 4930 -2340 4940 -2340 {lab=VSS}
N 4940 -2340 4940 -2310 {lab=VSS}
N 4930 -2140 4940 -2140 {lab=VSS}
N 4940 -2140 4940 -2110 {lab=VSS}
N 4930 -2360 4950 -2360 {lab=VDD}
N 4930 -2160 4950 -2160 {lab=VDD}
N 3750 -2450 4170 -2450 {lab=WL0}
N 3750 -2250 4170 -2250 {lab=WL1}
N 2830 -2450 3290 -2450 {lab=WL0}
N 2830 -2250 3290 -2250 {lab=WL1}
N 5150 -2450 5150 -2400 {lab=#net1}
N 5150 -2450 5560 -2450 {lab=#net1}
N 5560 -2450 5560 -2400 {lab=#net1}
N 5100 -2450 5150 -2450 {lab=#net1}
N 5150 -2250 5150 -2200 {lab=#net2}
N 5150 -2250 5560 -2250 {lab=#net2}
N 5560 -2250 5560 -2200 {lab=#net2}
N 5100 -2250 5150 -2250 {lab=#net2}
N 5450 -2380 5480 -2380 {lab=BL8}
N 5480 -2380 5480 -2090 {lab=BL8}
N 5450 -2180 5480 -2180 {lab=BL8}
N 5450 -2400 5500 -2400 {lab=BLB8}
N 5500 -2400 5500 -2090 {lab=BLB8}
N 5450 -2200 5500 -2200 {lab=BLB8}
N 5860 -2380 5890 -2380 {lab=BL9}
N 5890 -2380 5890 -2090 {lab=BL9}
N 5860 -2180 5890 -2180 {lab=BL9}
N 5860 -2400 5910 -2400 {lab=BLB9}
N 5910 -2400 5910 -2090 {lab=BLB9}
N 5860 -2200 5910 -2200 {lab=BLB9}
N 5450 -2160 5470 -2160 {lab=VDD}
N 5450 -2360 5470 -2360 {lab=VDD}
N 5450 -2340 5460 -2340 {lab=VSS}
N 5460 -2340 5460 -2310 {lab=VSS}
N 5450 -2140 5460 -2140 {lab=VSS}
N 5460 -2140 5460 -2110 {lab=VSS}
N 5860 -2340 5870 -2340 {lab=VSS}
N 5870 -2340 5870 -2310 {lab=VSS}
N 5860 -2140 5870 -2140 {lab=VSS}
N 5870 -2140 5870 -2110 {lab=VSS}
N 5860 -2360 5880 -2360 {lab=VDD}
N 5860 -2160 5880 -2160 {lab=VDD}
N 6030 -2450 6030 -2400 {lab=#net1}
N 6030 -2450 6440 -2450 {lab=#net1}
N 6440 -2450 6440 -2400 {lab=#net1}
N 5980 -2450 6030 -2450 {lab=#net1}
N 6030 -2250 6030 -2200 {lab=#net2}
N 6030 -2250 6440 -2250 {lab=#net2}
N 6440 -2250 6440 -2200 {lab=#net2}
N 5980 -2250 6030 -2250 {lab=#net2}
N 6330 -2380 6360 -2380 {lab=BL10}
N 6360 -2380 6360 -2090 {lab=BL10}
N 6330 -2180 6360 -2180 {lab=BL10}
N 6330 -2400 6380 -2400 {lab=BLB10}
N 6380 -2400 6380 -2090 {lab=BLB10}
N 6330 -2200 6380 -2200 {lab=BLB10}
N 6740 -2380 6770 -2380 {lab=BL11}
N 6770 -2380 6770 -2090 {lab=BL11}
N 6740 -2180 6770 -2180 {lab=BL11}
N 6740 -2400 6790 -2400 {lab=BLB11}
N 6790 -2400 6790 -2090 {lab=BLB11}
N 6740 -2200 6790 -2200 {lab=BLB11}
N 6330 -2160 6350 -2160 {lab=VDD}
N 6330 -2360 6350 -2360 {lab=VDD}
N 6330 -2340 6340 -2340 {lab=VSS}
N 6340 -2340 6340 -2310 {lab=VSS}
N 6330 -2140 6340 -2140 {lab=VSS}
N 6340 -2140 6340 -2110 {lab=VSS}
N 6740 -2340 6750 -2340 {lab=VSS}
N 6750 -2340 6750 -2310 {lab=VSS}
N 6740 -2140 6750 -2140 {lab=VSS}
N 6750 -2140 6750 -2110 {lab=VSS}
N 6740 -2360 6760 -2360 {lab=VDD}
N 6740 -2160 6760 -2160 {lab=VDD}
N 5560 -2450 5980 -2450 {lab=#net1}
N 5560 -2250 5980 -2250 {lab=#net2}
N 6950 -2450 6950 -2400 {lab=#net1}
N 6950 -2450 7360 -2450 {lab=#net1}
N 7360 -2450 7360 -2400 {lab=#net1}
N 6900 -2450 6950 -2450 {lab=#net1}
N 6950 -2250 6950 -2200 {lab=#net2}
N 6950 -2250 7360 -2250 {lab=#net2}
N 7360 -2250 7360 -2200 {lab=#net2}
N 6900 -2250 6950 -2250 {lab=#net2}
N 7250 -2380 7280 -2380 {lab=BL12}
N 7280 -2380 7280 -2090 {lab=BL12}
N 7250 -2180 7280 -2180 {lab=BL12}
N 7250 -2400 7300 -2400 {lab=BLB12}
N 7300 -2400 7300 -2090 {lab=BLB12}
N 7250 -2200 7300 -2200 {lab=BLB12}
N 7660 -2380 7690 -2380 {lab=BL13}
N 7690 -2380 7690 -2090 {lab=BL13}
N 7660 -2180 7690 -2180 {lab=BL13}
N 7660 -2400 7710 -2400 {lab=BLB13}
N 7710 -2400 7710 -2090 {lab=BLB13}
N 7660 -2200 7710 -2200 {lab=BLB13}
N 7250 -2160 7270 -2160 {lab=VDD}
N 7250 -2360 7270 -2360 {lab=VDD}
N 7250 -2340 7260 -2340 {lab=VSS}
N 7260 -2340 7260 -2310 {lab=VSS}
N 7250 -2140 7260 -2140 {lab=VSS}
N 7260 -2140 7260 -2110 {lab=VSS}
N 7660 -2340 7670 -2340 {lab=VSS}
N 7670 -2340 7670 -2310 {lab=VSS}
N 7660 -2140 7670 -2140 {lab=VSS}
N 7670 -2140 7670 -2110 {lab=VSS}
N 7660 -2360 7680 -2360 {lab=VDD}
N 7660 -2160 7680 -2160 {lab=VDD}
N 7830 -2450 7830 -2400 {lab=#net1}
N 7830 -2450 8240 -2450 {lab=#net1}
N 8240 -2450 8240 -2400 {lab=#net1}
N 7780 -2450 7830 -2450 {lab=#net1}
N 7830 -2250 7830 -2200 {lab=#net2}
N 7830 -2250 8240 -2250 {lab=#net2}
N 8240 -2250 8240 -2200 {lab=#net2}
N 7780 -2250 7830 -2250 {lab=#net2}
N 8130 -2380 8160 -2380 {lab=BL14}
N 8160 -2380 8160 -2090 {lab=BL14}
N 8130 -2180 8160 -2180 {lab=BL14}
N 8130 -2400 8180 -2400 {lab=BLB14}
N 8180 -2400 8180 -2090 {lab=BLB14}
N 8130 -2200 8180 -2200 {lab=BLB14}
N 8540 -2380 8570 -2380 {lab=BL15}
N 8570 -2380 8570 -2090 {lab=BL15}
N 8540 -2180 8570 -2180 {lab=BL15}
N 8540 -2400 8590 -2400 {lab=BLB15}
N 8590 -2400 8590 -2090 {lab=BLB15}
N 8540 -2200 8590 -2200 {lab=BLB15}
N 8130 -2160 8150 -2160 {lab=VDD}
N 8130 -2360 8150 -2360 {lab=VDD}
N 8130 -2340 8140 -2340 {lab=VSS}
N 8140 -2340 8140 -2310 {lab=VSS}
N 8130 -2140 8140 -2140 {lab=VSS}
N 8140 -2140 8140 -2110 {lab=VSS}
N 8540 -2340 8550 -2340 {lab=VSS}
N 8550 -2340 8550 -2310 {lab=VSS}
N 8540 -2140 8550 -2140 {lab=VSS}
N 8550 -2140 8550 -2110 {lab=VSS}
N 8540 -2360 8560 -2360 {lab=VDD}
N 8540 -2160 8560 -2160 {lab=VDD}
N 7360 -2450 7780 -2450 {lab=#net1}
N 7360 -2250 7780 -2250 {lab=#net2}
N 6440 -2450 6900 -2450 {lab=#net1}
N 6440 -2250 6900 -2250 {lab=#net2}
N 4630 -2450 5100 -2450 {lab=WL0}
N 4630 -2250 5100 -2250 {lab=WL1}
N 1550 -1960 1550 -1910 {lab=WL0}
N 1550 -1960 1960 -1960 {lab=WL0}
N 1960 -1960 1960 -1910 {lab=WL0}
N 1500 -1960 1550 -1960 {lab=WL0}
N 1550 -1760 1550 -1710 {lab=WL1}
N 1550 -1760 1960 -1760 {lab=WL1}
N 1960 -1760 1960 -1710 {lab=WL1}
N 1500 -1760 1550 -1760 {lab=WL1}
N 1850 -1890 1880 -1890 {lab=BL0}
N 1880 -1890 1880 -1600 {lab=BL0}
N 1850 -1690 1880 -1690 {lab=BL0}
N 1850 -1910 1900 -1910 {lab=BLB0}
N 1900 -1910 1900 -1600 {lab=BLB0}
N 1850 -1710 1900 -1710 {lab=BLB0}
N 2260 -1890 2290 -1890 {lab=BL1}
N 2290 -1890 2290 -1600 {lab=BL1}
N 2260 -1690 2290 -1690 {lab=BL1}
N 2260 -1910 2310 -1910 {lab=BLB1}
N 2310 -1910 2310 -1600 {lab=BLB1}
N 2260 -1710 2310 -1710 {lab=BLB1}
N 1850 -1670 1870 -1670 {lab=VDD}
N 1850 -1870 1870 -1870 {lab=VDD}
N 1850 -1850 1860 -1850 {lab=VSS}
N 1860 -1850 1860 -1820 {lab=VSS}
N 1850 -1650 1860 -1650 {lab=VSS}
N 1860 -1650 1860 -1620 {lab=VSS}
N 2260 -1850 2270 -1850 {lab=VSS}
N 2270 -1850 2270 -1820 {lab=VSS}
N 2260 -1650 2270 -1650 {lab=VSS}
N 2270 -1650 2270 -1620 {lab=VSS}
N 2260 -1870 2280 -1870 {lab=VDD}
N 2260 -1670 2280 -1670 {lab=VDD}
N 2430 -1960 2430 -1910 {lab=WL0}
N 2430 -1960 2840 -1960 {lab=WL0}
N 2840 -1960 2840 -1910 {lab=WL0}
N 2380 -1960 2430 -1960 {lab=WL0}
N 2430 -1760 2430 -1710 {lab=WL1}
N 2430 -1760 2840 -1760 {lab=WL1}
N 2840 -1760 2840 -1710 {lab=WL1}
N 2380 -1760 2430 -1760 {lab=WL1}
N 2730 -1890 2760 -1890 {lab=BL2}
N 2760 -1890 2760 -1600 {lab=BL2}
N 2730 -1690 2760 -1690 {lab=BL2}
N 2730 -1910 2780 -1910 {lab=BLB2}
N 2780 -1910 2780 -1600 {lab=BLB2}
N 2730 -1710 2780 -1710 {lab=BLB2}
N 3140 -1890 3170 -1890 {lab=BL3}
N 3170 -1890 3170 -1600 {lab=BL3}
N 3140 -1690 3170 -1690 {lab=BL3}
N 3140 -1910 3190 -1910 {lab=BLB3}
N 3190 -1910 3190 -1600 {lab=BLB3}
N 3140 -1710 3190 -1710 {lab=BLB3}
N 2730 -1670 2750 -1670 {lab=VDD}
N 2730 -1870 2750 -1870 {lab=VDD}
N 2730 -1850 2740 -1850 {lab=VSS}
N 2740 -1850 2740 -1820 {lab=VSS}
N 2730 -1650 2740 -1650 {lab=VSS}
N 2740 -1650 2740 -1620 {lab=VSS}
N 3140 -1850 3150 -1850 {lab=VSS}
N 3150 -1850 3150 -1820 {lab=VSS}
N 3140 -1650 3150 -1650 {lab=VSS}
N 3150 -1650 3150 -1620 {lab=VSS}
N 3140 -1870 3160 -1870 {lab=VDD}
N 3140 -1670 3160 -1670 {lab=VDD}
N 1960 -1960 2380 -1960 {lab=WL0}
N 1960 -1760 2380 -1760 {lab=WL1}
N 3350 -1960 3350 -1910 {lab=WL0}
N 3350 -1960 3760 -1960 {lab=WL0}
N 3760 -1960 3760 -1910 {lab=WL0}
N 3300 -1960 3350 -1960 {lab=WL0}
N 3350 -1760 3350 -1710 {lab=WL1}
N 3350 -1760 3760 -1760 {lab=WL1}
N 3760 -1760 3760 -1710 {lab=WL1}
N 3300 -1760 3350 -1760 {lab=WL1}
N 3650 -1890 3680 -1890 {lab=BL4}
N 3680 -1890 3680 -1600 {lab=BL4}
N 3650 -1690 3680 -1690 {lab=BL4}
N 3650 -1910 3700 -1910 {lab=BLB4}
N 3700 -1910 3700 -1600 {lab=BLB4}
N 3650 -1710 3700 -1710 {lab=BLB4}
N 4060 -1890 4090 -1890 {lab=BL5}
N 4090 -1890 4090 -1600 {lab=BL5}
N 4060 -1690 4090 -1690 {lab=BL5}
N 4060 -1910 4110 -1910 {lab=BLB5}
N 4110 -1910 4110 -1600 {lab=BLB5}
N 4060 -1710 4110 -1710 {lab=BLB5}
N 3650 -1670 3670 -1670 {lab=VDD}
N 3650 -1870 3670 -1870 {lab=VDD}
N 3650 -1850 3660 -1850 {lab=VSS}
N 3660 -1850 3660 -1820 {lab=VSS}
N 3650 -1650 3660 -1650 {lab=VSS}
N 3660 -1650 3660 -1620 {lab=VSS}
N 4060 -1850 4070 -1850 {lab=VSS}
N 4070 -1850 4070 -1820 {lab=VSS}
N 4060 -1650 4070 -1650 {lab=VSS}
N 4070 -1650 4070 -1620 {lab=VSS}
N 4060 -1870 4080 -1870 {lab=VDD}
N 4060 -1670 4080 -1670 {lab=VDD}
N 4230 -1960 4230 -1910 {lab=WL0}
N 4230 -1960 4640 -1960 {lab=WL0}
N 4640 -1960 4640 -1910 {lab=WL0}
N 4180 -1960 4230 -1960 {lab=WL0}
N 4230 -1760 4230 -1710 {lab=WL1}
N 4230 -1760 4640 -1760 {lab=WL1}
N 4640 -1760 4640 -1710 {lab=WL1}
N 4180 -1760 4230 -1760 {lab=WL1}
N 4530 -1890 4560 -1890 {lab=BL6}
N 4560 -1890 4560 -1600 {lab=BL6}
N 4530 -1690 4560 -1690 {lab=BL6}
N 4530 -1910 4580 -1910 {lab=BLB6}
N 4580 -1910 4580 -1600 {lab=BLB6}
N 4530 -1710 4580 -1710 {lab=BLB6}
N 4940 -1890 4970 -1890 {lab=BL7}
N 4970 -1890 4970 -1600 {lab=BL7}
N 4940 -1690 4970 -1690 {lab=BL7}
N 4940 -1910 4990 -1910 {lab=BLB7}
N 4990 -1910 4990 -1600 {lab=BLB7}
N 4940 -1710 4990 -1710 {lab=BLB7}
N 4530 -1670 4550 -1670 {lab=VDD}
N 4530 -1870 4550 -1870 {lab=VDD}
N 4530 -1850 4540 -1850 {lab=VSS}
N 4540 -1850 4540 -1820 {lab=VSS}
N 4530 -1650 4540 -1650 {lab=VSS}
N 4540 -1650 4540 -1620 {lab=VSS}
N 4940 -1850 4950 -1850 {lab=VSS}
N 4950 -1850 4950 -1820 {lab=VSS}
N 4940 -1650 4950 -1650 {lab=VSS}
N 4950 -1650 4950 -1620 {lab=VSS}
N 4940 -1870 4960 -1870 {lab=VDD}
N 4940 -1670 4960 -1670 {lab=VDD}
N 3760 -1960 4180 -1960 {lab=WL0}
N 3760 -1760 4180 -1760 {lab=WL1}
N 2840 -1960 3300 -1960 {lab=WL0}
N 2840 -1760 3300 -1760 {lab=WL1}
N 5160 -1960 5160 -1910 {lab=#net1}
N 5160 -1960 5570 -1960 {lab=#net1}
N 5570 -1960 5570 -1910 {lab=#net1}
N 5110 -1960 5160 -1960 {lab=#net1}
N 5160 -1760 5160 -1710 {lab=#net2}
N 5160 -1760 5570 -1760 {lab=#net2}
N 5570 -1760 5570 -1710 {lab=#net2}
N 5110 -1760 5160 -1760 {lab=#net2}
N 5460 -1890 5490 -1890 {lab=BL8}
N 5490 -1890 5490 -1600 {lab=BL8}
N 5460 -1690 5490 -1690 {lab=BL8}
N 5460 -1910 5510 -1910 {lab=BLB8}
N 5510 -1910 5510 -1600 {lab=BLB8}
N 5460 -1710 5510 -1710 {lab=BLB8}
N 5870 -1890 5900 -1890 {lab=BL9}
N 5900 -1890 5900 -1600 {lab=BL9}
N 5870 -1690 5900 -1690 {lab=BL9}
N 5870 -1910 5920 -1910 {lab=BLB9}
N 5920 -1910 5920 -1600 {lab=BLB9}
N 5870 -1710 5920 -1710 {lab=BLB9}
N 5460 -1670 5480 -1670 {lab=VDD}
N 5460 -1870 5480 -1870 {lab=VDD}
N 5460 -1850 5470 -1850 {lab=VSS}
N 5470 -1850 5470 -1820 {lab=VSS}
N 5460 -1650 5470 -1650 {lab=VSS}
N 5470 -1650 5470 -1620 {lab=VSS}
N 5870 -1850 5880 -1850 {lab=VSS}
N 5880 -1850 5880 -1820 {lab=VSS}
N 5870 -1650 5880 -1650 {lab=VSS}
N 5880 -1650 5880 -1620 {lab=VSS}
N 5870 -1870 5890 -1870 {lab=VDD}
N 5870 -1670 5890 -1670 {lab=VDD}
N 6040 -1960 6040 -1910 {lab=#net1}
N 6040 -1960 6450 -1960 {lab=#net1}
N 6450 -1960 6450 -1910 {lab=#net1}
N 5990 -1960 6040 -1960 {lab=#net1}
N 6040 -1760 6040 -1710 {lab=#net2}
N 6040 -1760 6450 -1760 {lab=#net2}
N 6450 -1760 6450 -1710 {lab=#net2}
N 5990 -1760 6040 -1760 {lab=#net2}
N 6340 -1890 6370 -1890 {lab=BL10}
N 6370 -1890 6370 -1600 {lab=BL10}
N 6340 -1690 6370 -1690 {lab=BL10}
N 6340 -1910 6390 -1910 {lab=BLB10}
N 6390 -1910 6390 -1600 {lab=BLB10}
N 6340 -1710 6390 -1710 {lab=BLB10}
N 6750 -1890 6780 -1890 {lab=BL11}
N 6780 -1890 6780 -1600 {lab=BL11}
N 6750 -1690 6780 -1690 {lab=BL11}
N 6750 -1910 6800 -1910 {lab=BLB11}
N 6800 -1910 6800 -1600 {lab=BLB11}
N 6750 -1710 6800 -1710 {lab=BLB11}
N 6340 -1670 6360 -1670 {lab=VDD}
N 6340 -1870 6360 -1870 {lab=VDD}
N 6340 -1850 6350 -1850 {lab=VSS}
N 6350 -1850 6350 -1820 {lab=VSS}
N 6340 -1650 6350 -1650 {lab=VSS}
N 6350 -1650 6350 -1620 {lab=VSS}
N 6750 -1850 6760 -1850 {lab=VSS}
N 6760 -1850 6760 -1820 {lab=VSS}
N 6750 -1650 6760 -1650 {lab=VSS}
N 6760 -1650 6760 -1620 {lab=VSS}
N 6750 -1870 6770 -1870 {lab=VDD}
N 6750 -1670 6770 -1670 {lab=VDD}
N 5570 -1960 5990 -1960 {lab=#net1}
N 5570 -1760 5990 -1760 {lab=#net2}
N 6960 -1960 6960 -1910 {lab=#net1}
N 6960 -1960 7370 -1960 {lab=#net1}
N 7370 -1960 7370 -1910 {lab=#net1}
N 6910 -1960 6960 -1960 {lab=#net1}
N 6960 -1760 6960 -1710 {lab=#net2}
N 6960 -1760 7370 -1760 {lab=#net2}
N 7370 -1760 7370 -1710 {lab=#net2}
N 6910 -1760 6960 -1760 {lab=#net2}
N 7260 -1890 7290 -1890 {lab=BL12}
N 7290 -1890 7290 -1600 {lab=BL12}
N 7260 -1690 7290 -1690 {lab=BL12}
N 7260 -1910 7310 -1910 {lab=BLB12}
N 7310 -1910 7310 -1600 {lab=BLB12}
N 7260 -1710 7310 -1710 {lab=BLB12}
N 7670 -1890 7700 -1890 {lab=BL13}
N 7700 -1890 7700 -1600 {lab=BL13}
N 7670 -1690 7700 -1690 {lab=BL13}
N 7670 -1910 7720 -1910 {lab=BLB13}
N 7720 -1910 7720 -1600 {lab=BLB13}
N 7670 -1710 7720 -1710 {lab=BLB13}
N 7260 -1670 7280 -1670 {lab=VDD}
N 7260 -1870 7280 -1870 {lab=VDD}
N 7260 -1850 7270 -1850 {lab=VSS}
N 7270 -1850 7270 -1820 {lab=VSS}
N 7260 -1650 7270 -1650 {lab=VSS}
N 7270 -1650 7270 -1620 {lab=VSS}
N 7670 -1850 7680 -1850 {lab=VSS}
N 7680 -1850 7680 -1820 {lab=VSS}
N 7670 -1650 7680 -1650 {lab=VSS}
N 7680 -1650 7680 -1620 {lab=VSS}
N 7670 -1870 7690 -1870 {lab=VDD}
N 7670 -1670 7690 -1670 {lab=VDD}
N 7840 -1960 7840 -1910 {lab=#net1}
N 7840 -1960 8250 -1960 {lab=#net1}
N 8250 -1960 8250 -1910 {lab=#net1}
N 7790 -1960 7840 -1960 {lab=#net1}
N 7840 -1760 7840 -1710 {lab=#net2}
N 7840 -1760 8250 -1760 {lab=#net2}
N 8250 -1760 8250 -1710 {lab=#net2}
N 7790 -1760 7840 -1760 {lab=#net2}
N 8140 -1890 8170 -1890 {lab=BL14}
N 8170 -1890 8170 -1600 {lab=BL14}
N 8140 -1690 8170 -1690 {lab=BL14}
N 8140 -1910 8190 -1910 {lab=BLB14}
N 8190 -1910 8190 -1600 {lab=BLB14}
N 8140 -1710 8190 -1710 {lab=BLB14}
N 8550 -1890 8580 -1890 {lab=BL15}
N 8580 -1890 8580 -1600 {lab=BL15}
N 8550 -1690 8580 -1690 {lab=BL15}
N 8550 -1910 8600 -1910 {lab=BLB15}
N 8600 -1910 8600 -1600 {lab=BLB15}
N 8550 -1710 8600 -1710 {lab=BLB15}
N 8140 -1670 8160 -1670 {lab=VDD}
N 8140 -1870 8160 -1870 {lab=VDD}
N 8140 -1850 8150 -1850 {lab=VSS}
N 8150 -1850 8150 -1820 {lab=VSS}
N 8140 -1650 8150 -1650 {lab=VSS}
N 8150 -1650 8150 -1620 {lab=VSS}
N 8550 -1850 8560 -1850 {lab=VSS}
N 8560 -1850 8560 -1820 {lab=VSS}
N 8550 -1650 8560 -1650 {lab=VSS}
N 8560 -1650 8560 -1620 {lab=VSS}
N 8550 -1870 8570 -1870 {lab=VDD}
N 8550 -1670 8570 -1670 {lab=VDD}
N 7370 -1960 7790 -1960 {lab=#net1}
N 7370 -1760 7790 -1760 {lab=#net2}
N 6450 -1960 6910 -1960 {lab=#net1}
N 6450 -1760 6910 -1760 {lab=#net2}
N 4640 -1960 5110 -1960 {lab=WL0}
N 4640 -1760 5110 -1760 {lab=WL1}
N 1540 -1480 1540 -1430 {lab=WL0}
N 1540 -1480 1950 -1480 {lab=WL0}
N 1950 -1480 1950 -1430 {lab=WL0}
N 1490 -1480 1540 -1480 {lab=WL0}
N 1540 -1280 1540 -1230 {lab=WL1}
N 1540 -1280 1950 -1280 {lab=WL1}
N 1950 -1280 1950 -1230 {lab=WL1}
N 1490 -1280 1540 -1280 {lab=WL1}
N 1840 -1410 1870 -1410 {lab=BL0}
N 1870 -1410 1870 -1120 {lab=BL0}
N 1840 -1210 1870 -1210 {lab=BL0}
N 1840 -1430 1890 -1430 {lab=BLB0}
N 1890 -1430 1890 -1120 {lab=BLB0}
N 1840 -1230 1890 -1230 {lab=BLB0}
N 2250 -1410 2280 -1410 {lab=BL1}
N 2280 -1410 2280 -1120 {lab=BL1}
N 2250 -1210 2280 -1210 {lab=BL1}
N 2250 -1430 2300 -1430 {lab=BLB1}
N 2300 -1430 2300 -1120 {lab=BLB1}
N 2250 -1230 2300 -1230 {lab=BLB1}
N 1840 -1190 1860 -1190 {lab=VDD}
N 1840 -1390 1860 -1390 {lab=VDD}
N 1840 -1370 1850 -1370 {lab=VSS}
N 1850 -1370 1850 -1340 {lab=VSS}
N 1840 -1170 1850 -1170 {lab=VSS}
N 1850 -1170 1850 -1140 {lab=VSS}
N 2250 -1370 2260 -1370 {lab=VSS}
N 2260 -1370 2260 -1340 {lab=VSS}
N 2250 -1170 2260 -1170 {lab=VSS}
N 2260 -1170 2260 -1140 {lab=VSS}
N 2250 -1390 2270 -1390 {lab=VDD}
N 2250 -1190 2270 -1190 {lab=VDD}
N 2420 -1480 2420 -1430 {lab=WL0}
N 2420 -1480 2830 -1480 {lab=WL0}
N 2830 -1480 2830 -1430 {lab=WL0}
N 2370 -1480 2420 -1480 {lab=WL0}
N 2420 -1280 2420 -1230 {lab=WL1}
N 2420 -1280 2830 -1280 {lab=WL1}
N 2830 -1280 2830 -1230 {lab=WL1}
N 2370 -1280 2420 -1280 {lab=WL1}
N 2720 -1410 2750 -1410 {lab=BL2}
N 2750 -1410 2750 -1120 {lab=BL2}
N 2720 -1210 2750 -1210 {lab=BL2}
N 2720 -1430 2770 -1430 {lab=BLB2}
N 2770 -1430 2770 -1120 {lab=BLB2}
N 2720 -1230 2770 -1230 {lab=BLB2}
N 3130 -1410 3160 -1410 {lab=BL3}
N 3160 -1410 3160 -1120 {lab=BL3}
N 3130 -1210 3160 -1210 {lab=BL3}
N 3130 -1430 3180 -1430 {lab=BLB3}
N 3180 -1430 3180 -1120 {lab=BLB3}
N 3130 -1230 3180 -1230 {lab=BLB3}
N 2720 -1190 2740 -1190 {lab=VDD}
N 2720 -1390 2740 -1390 {lab=VDD}
N 2720 -1370 2730 -1370 {lab=VSS}
N 2730 -1370 2730 -1340 {lab=VSS}
N 2720 -1170 2730 -1170 {lab=VSS}
N 2730 -1170 2730 -1140 {lab=VSS}
N 3130 -1370 3140 -1370 {lab=VSS}
N 3140 -1370 3140 -1340 {lab=VSS}
N 3130 -1170 3140 -1170 {lab=VSS}
N 3140 -1170 3140 -1140 {lab=VSS}
N 3130 -1390 3150 -1390 {lab=VDD}
N 3130 -1190 3150 -1190 {lab=VDD}
N 1950 -1480 2370 -1480 {lab=WL0}
N 1950 -1280 2370 -1280 {lab=WL1}
N 3340 -1480 3340 -1430 {lab=WL0}
N 3340 -1480 3750 -1480 {lab=WL0}
N 3750 -1480 3750 -1430 {lab=WL0}
N 3290 -1480 3340 -1480 {lab=WL0}
N 3340 -1280 3340 -1230 {lab=WL1}
N 3340 -1280 3750 -1280 {lab=WL1}
N 3750 -1280 3750 -1230 {lab=WL1}
N 3290 -1280 3340 -1280 {lab=WL1}
N 3640 -1410 3670 -1410 {lab=BL4}
N 3670 -1410 3670 -1120 {lab=BL4}
N 3640 -1210 3670 -1210 {lab=BL4}
N 3640 -1430 3690 -1430 {lab=BLB4}
N 3690 -1430 3690 -1120 {lab=BLB4}
N 3640 -1230 3690 -1230 {lab=BLB4}
N 4050 -1410 4080 -1410 {lab=BL5}
N 4080 -1410 4080 -1120 {lab=BL5}
N 4050 -1210 4080 -1210 {lab=BL5}
N 4050 -1430 4100 -1430 {lab=BLB5}
N 4100 -1430 4100 -1120 {lab=BLB5}
N 4050 -1230 4100 -1230 {lab=BLB5}
N 3640 -1190 3660 -1190 {lab=VDD}
N 3640 -1390 3660 -1390 {lab=VDD}
N 3640 -1370 3650 -1370 {lab=VSS}
N 3650 -1370 3650 -1340 {lab=VSS}
N 3640 -1170 3650 -1170 {lab=VSS}
N 3650 -1170 3650 -1140 {lab=VSS}
N 4050 -1370 4060 -1370 {lab=VSS}
N 4060 -1370 4060 -1340 {lab=VSS}
N 4050 -1170 4060 -1170 {lab=VSS}
N 4060 -1170 4060 -1140 {lab=VSS}
N 4050 -1390 4070 -1390 {lab=VDD}
N 4050 -1190 4070 -1190 {lab=VDD}
N 4220 -1480 4220 -1430 {lab=WL0}
N 4220 -1480 4630 -1480 {lab=WL0}
N 4630 -1480 4630 -1430 {lab=WL0}
N 4170 -1480 4220 -1480 {lab=WL0}
N 4220 -1280 4220 -1230 {lab=WL1}
N 4220 -1280 4630 -1280 {lab=WL1}
N 4630 -1280 4630 -1230 {lab=WL1}
N 4170 -1280 4220 -1280 {lab=WL1}
N 4520 -1410 4550 -1410 {lab=BL6}
N 4550 -1410 4550 -1120 {lab=BL6}
N 4520 -1210 4550 -1210 {lab=BL6}
N 4520 -1430 4570 -1430 {lab=BLB6}
N 4570 -1430 4570 -1120 {lab=BLB6}
N 4520 -1230 4570 -1230 {lab=BLB6}
N 4930 -1410 4960 -1410 {lab=BL7}
N 4960 -1410 4960 -1120 {lab=BL7}
N 4930 -1210 4960 -1210 {lab=BL7}
N 4930 -1430 4980 -1430 {lab=BLB7}
N 4980 -1430 4980 -1120 {lab=BLB7}
N 4930 -1230 4980 -1230 {lab=BLB7}
N 4520 -1190 4540 -1190 {lab=VDD}
N 4520 -1390 4540 -1390 {lab=VDD}
N 4520 -1370 4530 -1370 {lab=VSS}
N 4530 -1370 4530 -1340 {lab=VSS}
N 4520 -1170 4530 -1170 {lab=VSS}
N 4530 -1170 4530 -1140 {lab=VSS}
N 4930 -1370 4940 -1370 {lab=VSS}
N 4940 -1370 4940 -1340 {lab=VSS}
N 4930 -1170 4940 -1170 {lab=VSS}
N 4940 -1170 4940 -1140 {lab=VSS}
N 4930 -1390 4950 -1390 {lab=VDD}
N 4930 -1190 4950 -1190 {lab=VDD}
N 3750 -1480 4170 -1480 {lab=WL0}
N 3750 -1280 4170 -1280 {lab=WL1}
N 2830 -1480 3290 -1480 {lab=WL0}
N 2830 -1280 3290 -1280 {lab=WL1}
N 5150 -1480 5150 -1430 {lab=#net1}
N 5150 -1480 5560 -1480 {lab=#net1}
N 5560 -1480 5560 -1430 {lab=#net1}
N 5100 -1480 5150 -1480 {lab=#net1}
N 5150 -1280 5150 -1230 {lab=#net2}
N 5150 -1280 5560 -1280 {lab=#net2}
N 5560 -1280 5560 -1230 {lab=#net2}
N 5100 -1280 5150 -1280 {lab=#net2}
N 5450 -1410 5480 -1410 {lab=BL8}
N 5480 -1410 5480 -1120 {lab=BL8}
N 5450 -1210 5480 -1210 {lab=BL8}
N 5450 -1430 5500 -1430 {lab=BLB8}
N 5500 -1430 5500 -1120 {lab=BLB8}
N 5450 -1230 5500 -1230 {lab=BLB8}
N 5860 -1410 5890 -1410 {lab=BL9}
N 5890 -1410 5890 -1120 {lab=BL9}
N 5860 -1210 5890 -1210 {lab=BL9}
N 5860 -1430 5910 -1430 {lab=BLB9}
N 5910 -1430 5910 -1120 {lab=BLB9}
N 5860 -1230 5910 -1230 {lab=BLB9}
N 5450 -1190 5470 -1190 {lab=VDD}
N 5450 -1390 5470 -1390 {lab=VDD}
N 5450 -1370 5460 -1370 {lab=VSS}
N 5460 -1370 5460 -1340 {lab=VSS}
N 5450 -1170 5460 -1170 {lab=VSS}
N 5460 -1170 5460 -1140 {lab=VSS}
N 5860 -1370 5870 -1370 {lab=VSS}
N 5870 -1370 5870 -1340 {lab=VSS}
N 5860 -1170 5870 -1170 {lab=VSS}
N 5870 -1170 5870 -1140 {lab=VSS}
N 5860 -1390 5880 -1390 {lab=VDD}
N 5860 -1190 5880 -1190 {lab=VDD}
N 6030 -1480 6030 -1430 {lab=#net1}
N 6030 -1480 6440 -1480 {lab=#net1}
N 6440 -1480 6440 -1430 {lab=#net1}
N 5980 -1480 6030 -1480 {lab=#net1}
N 6030 -1280 6030 -1230 {lab=#net2}
N 6030 -1280 6440 -1280 {lab=#net2}
N 6440 -1280 6440 -1230 {lab=#net2}
N 5980 -1280 6030 -1280 {lab=#net2}
N 6330 -1410 6360 -1410 {lab=BL10}
N 6360 -1410 6360 -1120 {lab=BL10}
N 6330 -1210 6360 -1210 {lab=BL10}
N 6330 -1430 6380 -1430 {lab=BLB10}
N 6380 -1430 6380 -1120 {lab=BLB10}
N 6330 -1230 6380 -1230 {lab=BLB10}
N 6740 -1410 6770 -1410 {lab=BL11}
N 6770 -1410 6770 -1120 {lab=BL11}
N 6740 -1210 6770 -1210 {lab=BL11}
N 6740 -1430 6790 -1430 {lab=BLB11}
N 6790 -1430 6790 -1120 {lab=BLB11}
N 6740 -1230 6790 -1230 {lab=BLB11}
N 6330 -1190 6350 -1190 {lab=VDD}
N 6330 -1390 6350 -1390 {lab=VDD}
N 6330 -1370 6340 -1370 {lab=VSS}
N 6340 -1370 6340 -1340 {lab=VSS}
N 6330 -1170 6340 -1170 {lab=VSS}
N 6340 -1170 6340 -1140 {lab=VSS}
N 6740 -1370 6750 -1370 {lab=VSS}
N 6750 -1370 6750 -1340 {lab=VSS}
N 6740 -1170 6750 -1170 {lab=VSS}
N 6750 -1170 6750 -1140 {lab=VSS}
N 6740 -1390 6760 -1390 {lab=VDD}
N 6740 -1190 6760 -1190 {lab=VDD}
N 5560 -1480 5980 -1480 {lab=#net1}
N 5560 -1280 5980 -1280 {lab=#net2}
N 6950 -1480 6950 -1430 {lab=#net1}
N 6950 -1480 7360 -1480 {lab=#net1}
N 7360 -1480 7360 -1430 {lab=#net1}
N 6900 -1480 6950 -1480 {lab=#net1}
N 6950 -1280 6950 -1230 {lab=#net2}
N 6950 -1280 7360 -1280 {lab=#net2}
N 7360 -1280 7360 -1230 {lab=#net2}
N 6900 -1280 6950 -1280 {lab=#net2}
N 7250 -1410 7280 -1410 {lab=BL12}
N 7280 -1410 7280 -1120 {lab=BL12}
N 7250 -1210 7280 -1210 {lab=BL12}
N 7250 -1430 7300 -1430 {lab=BLB12}
N 7300 -1430 7300 -1120 {lab=BLB12}
N 7250 -1230 7300 -1230 {lab=BLB12}
N 7660 -1410 7690 -1410 {lab=BL13}
N 7690 -1410 7690 -1120 {lab=BL13}
N 7660 -1210 7690 -1210 {lab=BL13}
N 7660 -1430 7710 -1430 {lab=BLB13}
N 7710 -1430 7710 -1120 {lab=BLB13}
N 7660 -1230 7710 -1230 {lab=BLB13}
N 7250 -1190 7270 -1190 {lab=VDD}
N 7250 -1390 7270 -1390 {lab=VDD}
N 7250 -1370 7260 -1370 {lab=VSS}
N 7260 -1370 7260 -1340 {lab=VSS}
N 7250 -1170 7260 -1170 {lab=VSS}
N 7260 -1170 7260 -1140 {lab=VSS}
N 7660 -1370 7670 -1370 {lab=VSS}
N 7670 -1370 7670 -1340 {lab=VSS}
N 7660 -1170 7670 -1170 {lab=VSS}
N 7670 -1170 7670 -1140 {lab=VSS}
N 7660 -1390 7680 -1390 {lab=VDD}
N 7660 -1190 7680 -1190 {lab=VDD}
N 7830 -1480 7830 -1430 {lab=#net1}
N 7830 -1480 8240 -1480 {lab=#net1}
N 8240 -1480 8240 -1430 {lab=#net1}
N 7780 -1480 7830 -1480 {lab=#net1}
N 7830 -1280 7830 -1230 {lab=#net2}
N 7830 -1280 8240 -1280 {lab=#net2}
N 8240 -1280 8240 -1230 {lab=#net2}
N 7780 -1280 7830 -1280 {lab=#net2}
N 8130 -1410 8160 -1410 {lab=BL14}
N 8160 -1410 8160 -1120 {lab=BL14}
N 8130 -1210 8160 -1210 {lab=BL14}
N 8130 -1430 8180 -1430 {lab=BLB14}
N 8180 -1430 8180 -1120 {lab=BLB14}
N 8130 -1230 8180 -1230 {lab=BLB14}
N 8540 -1410 8570 -1410 {lab=BL15}
N 8570 -1410 8570 -1120 {lab=BL15}
N 8540 -1210 8570 -1210 {lab=BL15}
N 8540 -1430 8590 -1430 {lab=BLB15}
N 8590 -1430 8590 -1120 {lab=BLB15}
N 8540 -1230 8590 -1230 {lab=BLB15}
N 8130 -1190 8150 -1190 {lab=VDD}
N 8130 -1390 8150 -1390 {lab=VDD}
N 8130 -1370 8140 -1370 {lab=VSS}
N 8140 -1370 8140 -1340 {lab=VSS}
N 8130 -1170 8140 -1170 {lab=VSS}
N 8140 -1170 8140 -1140 {lab=VSS}
N 8540 -1370 8550 -1370 {lab=VSS}
N 8550 -1370 8550 -1340 {lab=VSS}
N 8540 -1170 8550 -1170 {lab=VSS}
N 8550 -1170 8550 -1140 {lab=VSS}
N 8540 -1390 8560 -1390 {lab=VDD}
N 8540 -1190 8560 -1190 {lab=VDD}
N 7360 -1480 7780 -1480 {lab=#net1}
N 7360 -1280 7780 -1280 {lab=#net2}
N 6440 -1480 6900 -1480 {lab=#net1}
N 6440 -1280 6900 -1280 {lab=#net2}
N 4630 -1480 5100 -1480 {lab=WL0}
N 4630 -1280 5100 -1280 {lab=WL1}
N 1550 -990 1550 -940 {lab=WL0}
N 1550 -990 1960 -990 {lab=WL0}
N 1960 -990 1960 -940 {lab=WL0}
N 1500 -990 1550 -990 {lab=WL0}
N 1550 -790 1550 -740 {lab=WL1}
N 1550 -790 1960 -790 {lab=WL1}
N 1960 -790 1960 -740 {lab=WL1}
N 1500 -790 1550 -790 {lab=WL1}
N 1850 -920 1880 -920 {lab=BL0}
N 1880 -920 1880 -630 {lab=BL0}
N 1850 -720 1880 -720 {lab=BL0}
N 1850 -940 1900 -940 {lab=BLB0}
N 1900 -940 1900 -630 {lab=BLB0}
N 1850 -740 1900 -740 {lab=BLB0}
N 2260 -920 2290 -920 {lab=BL1}
N 2290 -920 2290 -630 {lab=BL1}
N 2260 -720 2290 -720 {lab=BL1}
N 2260 -940 2310 -940 {lab=BLB1}
N 2310 -940 2310 -630 {lab=BLB1}
N 2260 -740 2310 -740 {lab=BLB1}
N 1850 -700 1870 -700 {lab=VDD}
N 1850 -900 1870 -900 {lab=VDD}
N 1850 -880 1860 -880 {lab=VSS}
N 1860 -880 1860 -850 {lab=VSS}
N 1850 -680 1860 -680 {lab=VSS}
N 1860 -680 1860 -650 {lab=VSS}
N 2260 -880 2270 -880 {lab=VSS}
N 2270 -880 2270 -850 {lab=VSS}
N 2260 -680 2270 -680 {lab=VSS}
N 2270 -680 2270 -650 {lab=VSS}
N 2260 -900 2280 -900 {lab=VDD}
N 2260 -700 2280 -700 {lab=VDD}
N 2430 -990 2430 -940 {lab=WL0}
N 2430 -990 2840 -990 {lab=WL0}
N 2840 -990 2840 -940 {lab=WL0}
N 2380 -990 2430 -990 {lab=WL0}
N 2430 -790 2430 -740 {lab=WL1}
N 2430 -790 2840 -790 {lab=WL1}
N 2840 -790 2840 -740 {lab=WL1}
N 2380 -790 2430 -790 {lab=WL1}
N 2730 -920 2760 -920 {lab=BL2}
N 2760 -920 2760 -630 {lab=BL2}
N 2730 -720 2760 -720 {lab=BL2}
N 2730 -940 2780 -940 {lab=BLB2}
N 2780 -940 2780 -630 {lab=BLB2}
N 2730 -740 2780 -740 {lab=BLB2}
N 3140 -920 3170 -920 {lab=BL3}
N 3170 -920 3170 -630 {lab=BL3}
N 3140 -720 3170 -720 {lab=BL3}
N 3140 -940 3190 -940 {lab=BLB3}
N 3190 -940 3190 -630 {lab=BLB3}
N 3140 -740 3190 -740 {lab=BLB3}
N 2730 -700 2750 -700 {lab=VDD}
N 2730 -900 2750 -900 {lab=VDD}
N 2730 -880 2740 -880 {lab=VSS}
N 2740 -880 2740 -850 {lab=VSS}
N 2730 -680 2740 -680 {lab=VSS}
N 2740 -680 2740 -650 {lab=VSS}
N 3140 -880 3150 -880 {lab=VSS}
N 3150 -880 3150 -850 {lab=VSS}
N 3140 -680 3150 -680 {lab=VSS}
N 3150 -680 3150 -650 {lab=VSS}
N 3140 -900 3160 -900 {lab=VDD}
N 3140 -700 3160 -700 {lab=VDD}
N 1960 -990 2380 -990 {lab=WL0}
N 1960 -790 2380 -790 {lab=WL1}
N 3350 -990 3350 -940 {lab=WL0}
N 3350 -990 3760 -990 {lab=WL0}
N 3760 -990 3760 -940 {lab=WL0}
N 3300 -990 3350 -990 {lab=WL0}
N 3350 -790 3350 -740 {lab=WL1}
N 3350 -790 3760 -790 {lab=WL1}
N 3760 -790 3760 -740 {lab=WL1}
N 3300 -790 3350 -790 {lab=WL1}
N 3650 -920 3680 -920 {lab=BL4}
N 3680 -920 3680 -630 {lab=BL4}
N 3650 -720 3680 -720 {lab=BL4}
N 3650 -940 3700 -940 {lab=BLB4}
N 3700 -940 3700 -630 {lab=BLB4}
N 3650 -740 3700 -740 {lab=BLB4}
N 4060 -920 4090 -920 {lab=BL5}
N 4090 -920 4090 -630 {lab=BL5}
N 4060 -720 4090 -720 {lab=BL5}
N 4060 -940 4110 -940 {lab=BLB5}
N 4110 -940 4110 -630 {lab=BLB5}
N 4060 -740 4110 -740 {lab=BLB5}
N 3650 -700 3670 -700 {lab=VDD}
N 3650 -900 3670 -900 {lab=VDD}
N 3650 -880 3660 -880 {lab=VSS}
N 3660 -880 3660 -850 {lab=VSS}
N 3650 -680 3660 -680 {lab=VSS}
N 3660 -680 3660 -650 {lab=VSS}
N 4060 -880 4070 -880 {lab=VSS}
N 4070 -880 4070 -850 {lab=VSS}
N 4060 -680 4070 -680 {lab=VSS}
N 4070 -680 4070 -650 {lab=VSS}
N 4060 -900 4080 -900 {lab=VDD}
N 4060 -700 4080 -700 {lab=VDD}
N 4230 -990 4230 -940 {lab=WL0}
N 4230 -990 4640 -990 {lab=WL0}
N 4640 -990 4640 -940 {lab=WL0}
N 4180 -990 4230 -990 {lab=WL0}
N 4230 -790 4230 -740 {lab=WL1}
N 4230 -790 4640 -790 {lab=WL1}
N 4640 -790 4640 -740 {lab=WL1}
N 4180 -790 4230 -790 {lab=WL1}
N 4530 -920 4560 -920 {lab=BL6}
N 4560 -920 4560 -630 {lab=BL6}
N 4530 -720 4560 -720 {lab=BL6}
N 4530 -940 4580 -940 {lab=BLB6}
N 4580 -940 4580 -630 {lab=BLB6}
N 4530 -740 4580 -740 {lab=BLB6}
N 4940 -920 4970 -920 {lab=BL7}
N 4970 -920 4970 -630 {lab=BL7}
N 4940 -720 4970 -720 {lab=BL7}
N 4940 -940 4990 -940 {lab=BLB7}
N 4990 -940 4990 -630 {lab=BLB7}
N 4940 -740 4990 -740 {lab=BLB7}
N 4530 -700 4550 -700 {lab=VDD}
N 4530 -900 4550 -900 {lab=VDD}
N 4530 -880 4540 -880 {lab=VSS}
N 4540 -880 4540 -850 {lab=VSS}
N 4530 -680 4540 -680 {lab=VSS}
N 4540 -680 4540 -650 {lab=VSS}
N 4940 -880 4950 -880 {lab=VSS}
N 4950 -880 4950 -850 {lab=VSS}
N 4940 -680 4950 -680 {lab=VSS}
N 4950 -680 4950 -650 {lab=VSS}
N 4940 -900 4960 -900 {lab=VDD}
N 4940 -700 4960 -700 {lab=VDD}
N 3760 -990 4180 -990 {lab=WL0}
N 3760 -790 4180 -790 {lab=WL1}
N 2840 -990 3300 -990 {lab=WL0}
N 2840 -790 3300 -790 {lab=WL1}
N 5160 -990 5160 -940 {lab=#net1}
N 5160 -990 5570 -990 {lab=#net1}
N 5570 -990 5570 -940 {lab=#net1}
N 5110 -990 5160 -990 {lab=#net1}
N 5160 -790 5160 -740 {lab=#net2}
N 5160 -790 5570 -790 {lab=#net2}
N 5570 -790 5570 -740 {lab=#net2}
N 5110 -790 5160 -790 {lab=#net2}
N 5460 -920 5490 -920 {lab=BL8}
N 5490 -920 5490 -630 {lab=BL8}
N 5460 -720 5490 -720 {lab=BL8}
N 5460 -940 5510 -940 {lab=BLB8}
N 5510 -940 5510 -630 {lab=BLB8}
N 5460 -740 5510 -740 {lab=BLB8}
N 5870 -920 5900 -920 {lab=BL9}
N 5900 -920 5900 -630 {lab=BL9}
N 5870 -720 5900 -720 {lab=BL9}
N 5870 -940 5920 -940 {lab=BLB9}
N 5920 -940 5920 -630 {lab=BLB9}
N 5870 -740 5920 -740 {lab=BLB9}
N 5460 -700 5480 -700 {lab=VDD}
N 5460 -900 5480 -900 {lab=VDD}
N 5460 -880 5470 -880 {lab=VSS}
N 5470 -880 5470 -850 {lab=VSS}
N 5460 -680 5470 -680 {lab=VSS}
N 5470 -680 5470 -650 {lab=VSS}
N 5870 -880 5880 -880 {lab=VSS}
N 5880 -880 5880 -850 {lab=VSS}
N 5870 -680 5880 -680 {lab=VSS}
N 5880 -680 5880 -650 {lab=VSS}
N 5870 -900 5890 -900 {lab=VDD}
N 5870 -700 5890 -700 {lab=VDD}
N 6040 -990 6040 -940 {lab=#net1}
N 6040 -990 6450 -990 {lab=#net1}
N 6450 -990 6450 -940 {lab=#net1}
N 5990 -990 6040 -990 {lab=#net1}
N 6040 -790 6040 -740 {lab=#net2}
N 6040 -790 6450 -790 {lab=#net2}
N 6450 -790 6450 -740 {lab=#net2}
N 5990 -790 6040 -790 {lab=#net2}
N 6340 -920 6370 -920 {lab=BL10}
N 6370 -920 6370 -630 {lab=BL10}
N 6340 -720 6370 -720 {lab=BL10}
N 6340 -940 6390 -940 {lab=BLB10}
N 6390 -940 6390 -630 {lab=BLB10}
N 6340 -740 6390 -740 {lab=BLB10}
N 6750 -920 6780 -920 {lab=BL11}
N 6780 -920 6780 -630 {lab=BL11}
N 6750 -720 6780 -720 {lab=BL11}
N 6750 -940 6800 -940 {lab=BLB11}
N 6800 -940 6800 -630 {lab=BLB11}
N 6750 -740 6800 -740 {lab=BLB11}
N 6340 -700 6360 -700 {lab=VDD}
N 6340 -900 6360 -900 {lab=VDD}
N 6340 -880 6350 -880 {lab=VSS}
N 6350 -880 6350 -850 {lab=VSS}
N 6340 -680 6350 -680 {lab=VSS}
N 6350 -680 6350 -650 {lab=VSS}
N 6750 -880 6760 -880 {lab=VSS}
N 6760 -880 6760 -850 {lab=VSS}
N 6750 -680 6760 -680 {lab=VSS}
N 6760 -680 6760 -650 {lab=VSS}
N 6750 -900 6770 -900 {lab=VDD}
N 6750 -700 6770 -700 {lab=VDD}
N 5570 -990 5990 -990 {lab=#net1}
N 5570 -790 5990 -790 {lab=#net2}
N 6960 -990 6960 -940 {lab=#net1}
N 6960 -990 7370 -990 {lab=#net1}
N 7370 -990 7370 -940 {lab=#net1}
N 6910 -990 6960 -990 {lab=#net1}
N 6960 -790 6960 -740 {lab=#net2}
N 6960 -790 7370 -790 {lab=#net2}
N 7370 -790 7370 -740 {lab=#net2}
N 6910 -790 6960 -790 {lab=#net2}
N 7260 -920 7290 -920 {lab=BL12}
N 7290 -920 7290 -630 {lab=BL12}
N 7260 -720 7290 -720 {lab=BL12}
N 7260 -940 7310 -940 {lab=BLB12}
N 7310 -940 7310 -630 {lab=BLB12}
N 7260 -740 7310 -740 {lab=BLB12}
N 7670 -920 7700 -920 {lab=BL13}
N 7700 -920 7700 -630 {lab=BL13}
N 7670 -720 7700 -720 {lab=BL13}
N 7670 -940 7720 -940 {lab=BLB13}
N 7720 -940 7720 -630 {lab=BLB13}
N 7670 -740 7720 -740 {lab=BLB13}
N 7260 -700 7280 -700 {lab=VDD}
N 7260 -900 7280 -900 {lab=VDD}
N 7260 -880 7270 -880 {lab=VSS}
N 7270 -880 7270 -850 {lab=VSS}
N 7260 -680 7270 -680 {lab=VSS}
N 7270 -680 7270 -650 {lab=VSS}
N 7670 -880 7680 -880 {lab=VSS}
N 7680 -880 7680 -850 {lab=VSS}
N 7670 -680 7680 -680 {lab=VSS}
N 7680 -680 7680 -650 {lab=VSS}
N 7670 -900 7690 -900 {lab=VDD}
N 7670 -700 7690 -700 {lab=VDD}
N 7840 -990 7840 -940 {lab=#net1}
N 7840 -990 8250 -990 {lab=#net1}
N 8250 -990 8250 -940 {lab=#net1}
N 7790 -990 7840 -990 {lab=#net1}
N 7840 -790 7840 -740 {lab=#net2}
N 7840 -790 8250 -790 {lab=#net2}
N 8250 -790 8250 -740 {lab=#net2}
N 7790 -790 7840 -790 {lab=#net2}
N 8140 -920 8170 -920 {lab=BL14}
N 8170 -920 8170 -630 {lab=BL14}
N 8140 -720 8170 -720 {lab=BL14}
N 8140 -940 8190 -940 {lab=BLB14}
N 8190 -940 8190 -630 {lab=BLB14}
N 8140 -740 8190 -740 {lab=BLB14}
N 8550 -920 8580 -920 {lab=BL15}
N 8580 -920 8580 -630 {lab=BL15}
N 8550 -720 8580 -720 {lab=BL15}
N 8550 -940 8600 -940 {lab=BLB15}
N 8600 -940 8600 -630 {lab=BLB15}
N 8550 -740 8600 -740 {lab=BLB15}
N 8140 -700 8160 -700 {lab=VDD}
N 8140 -900 8160 -900 {lab=VDD}
N 8140 -880 8150 -880 {lab=VSS}
N 8150 -880 8150 -850 {lab=VSS}
N 8140 -680 8150 -680 {lab=VSS}
N 8150 -680 8150 -650 {lab=VSS}
N 8550 -880 8560 -880 {lab=VSS}
N 8560 -880 8560 -850 {lab=VSS}
N 8550 -680 8560 -680 {lab=VSS}
N 8560 -680 8560 -650 {lab=VSS}
N 8550 -900 8570 -900 {lab=VDD}
N 8550 -700 8570 -700 {lab=VDD}
N 7370 -990 7790 -990 {lab=#net1}
N 7370 -790 7790 -790 {lab=#net2}
N 6450 -990 6910 -990 {lab=#net1}
N 6450 -790 6910 -790 {lab=#net2}
N 4640 -990 5110 -990 {lab=WL0}
N 4640 -790 5110 -790 {lab=WL1}
N 1790 -4740 1820 -4740 {lab=WL0}
N 1790 -4690 1820 -4690 {lab=WL1}
N 1960 -4740 1990 -4740 {lab=WL0}
N 1960 -4690 1990 -4690 {lab=WL1}
N 2160 -4740 2190 -4740 {lab=WL0}
N 2160 -4690 2190 -4690 {lab=WL1}
N 1590 -4620 1620 -4620 {lab=WL0}
N 1590 -4570 1620 -4570 {lab=WL1}
N 1790 -4620 1820 -4620 {lab=WL0}
N 1790 -4570 1820 -4570 {lab=WL1}
N 1960 -4620 1990 -4620 {lab=WL0}
N 1960 -4570 1990 -4570 {lab=WL1}
N 2160 -4620 2190 -4620 {lab=WL0}
N 2160 -4570 2190 -4570 {lab=WL1}
C {devices/lab_pin.sym} 1880 -4310 1 1 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2290 -4310 1 1 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1880 -4110 1 1 {name=p3 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2290 -4110 1 1 {name=p4 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1510 -4400 0 0 {name=p5 sig_type=std_logic lab=WL0}
C {devices/lab_pin.sym} 1510 -4200 0 0 {name=p6 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 1870 -4260 1 1 {name=p11 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2280 -4260 1 1 {name=p12 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1870 -4060 1 1 {name=p13 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2280 -4060 1 1 {name=p14 sig_type=std_logic lab=VSS}
C {devices/iopin.sym} 1420 -4740 0 0 {name=p15 lab=VDD}
C {devices/iopin.sym} 1420 -4690 0 0 {name=p16 lab=VSS}
C {devices/lab_pin.sym} 1390 -4740 0 0 {name=p23 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1390 -4690 0 0 {name=p24 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1590 -4740 0 0 {name=p25 sig_type=std_logic lab=WL0}
C {devices/lab_pin.sym} 1590 -4690 0 0 {name=p26 sig_type=std_logic lab=WL1}
C {devices/ipin.sym} 1620 -4740 0 1 {name=p17 lab=WL0}
C {devices/ipin.sym} 1620 -4690 0 1 {name=p18 lab=WL1}
C {sram6t_tr10.sym} 1710 -4120 0 0 {name=x1}
C {sram6t_tr10.sym} 1710 -4320 0 0 {name=x2}
C {sram6t_tr10.sym} 2120 -4320 0 0 {name=x3}
C {sram6t_tr10.sym} 2120 -4120 0 0 {name=x4}
C {devices/lab_pin.sym} 2760 -4310 1 1 {name=p31 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3170 -4310 1 1 {name=p32 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2760 -4110 1 1 {name=p33 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3170 -4110 1 1 {name=p34 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2750 -4260 1 1 {name=p39 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3160 -4260 1 1 {name=p40 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2750 -4060 1 1 {name=p41 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3160 -4060 1 1 {name=p42 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 2590 -4120 0 0 {name=x5}
C {sram6t_tr10.sym} 2590 -4320 0 0 {name=x6}
C {sram6t_tr10.sym} 3000 -4320 0 0 {name=x7}
C {sram6t_tr10.sym} 3000 -4120 0 0 {name=x8}
C {devices/lab_pin.sym} 3680 -4310 1 1 {name=p43 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4090 -4310 1 1 {name=p44 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3680 -4110 1 1 {name=p45 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4090 -4110 1 1 {name=p46 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3670 -4260 1 1 {name=p51 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4080 -4260 1 1 {name=p52 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3670 -4060 1 1 {name=p53 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4080 -4060 1 1 {name=p54 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 3510 -4120 0 0 {name=x9}
C {sram6t_tr10.sym} 3510 -4320 0 0 {name=x10}
C {sram6t_tr10.sym} 3920 -4320 0 0 {name=x11}
C {sram6t_tr10.sym} 3920 -4120 0 0 {name=x12}
C {devices/lab_pin.sym} 4560 -4310 1 1 {name=p55 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4970 -4310 1 1 {name=p56 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4560 -4110 1 1 {name=p57 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4970 -4110 1 1 {name=p58 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4550 -4260 1 1 {name=p63 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4960 -4260 1 1 {name=p64 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4550 -4060 1 1 {name=p65 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4960 -4060 1 1 {name=p66 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 4390 -4120 0 0 {name=x13}
C {sram6t_tr10.sym} 4390 -4320 0 0 {name=x14}
C {sram6t_tr10.sym} 4800 -4320 0 0 {name=x15}
C {sram6t_tr10.sym} 4800 -4120 0 0 {name=x16}
C {devices/iopin.sym} 1890 -4040 1 0 {name=p91 lab=BL0}
C {devices/iopin.sym} 1910 -4040 1 0 {name=p92 lab=BLB0}
C {devices/iopin.sym} 2300 -4040 1 0 {name=p7 lab=BL1}
C {devices/iopin.sym} 2320 -4040 1 0 {name=p8 lab=BLB1}
C {devices/iopin.sym} 2770 -4040 1 0 {name=p9 lab=BL2}
C {devices/iopin.sym} 2790 -4040 1 0 {name=p10 lab=BLB2}
C {devices/iopin.sym} 3180 -4040 1 0 {name=p19 lab=BL3}
C {devices/iopin.sym} 3200 -4040 1 0 {name=p20 lab=BLB3}
C {devices/iopin.sym} 3690 -4040 1 0 {name=p21 lab=BL4}
C {devices/iopin.sym} 3710 -4040 1 0 {name=p22 lab=BLB4}
C {devices/iopin.sym} 4100 -4040 1 0 {name=p27 lab=BL5}
C {devices/iopin.sym} 4120 -4040 1 0 {name=p28 lab=BLB5}
C {devices/iopin.sym} 4570 -4040 1 0 {name=p29 lab=BL6}
C {devices/iopin.sym} 4590 -4040 1 0 {name=p30 lab=BLB6}
C {devices/iopin.sym} 4980 -4040 1 0 {name=p35 lab=BL7}
C {devices/iopin.sym} 5000 -4040 1 0 {name=p36 lab=BLB7}
C {devices/lab_pin.sym} 5490 -4310 1 1 {name=p37 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5900 -4310 1 1 {name=p38 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5490 -4110 1 1 {name=p47 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5900 -4110 1 1 {name=p48 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5480 -4260 1 1 {name=p59 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5890 -4260 1 1 {name=p60 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5480 -4060 1 1 {name=p61 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5890 -4060 1 1 {name=p62 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 5320 -4120 0 0 {name=x17}
C {sram6t_tr10.sym} 5320 -4320 0 0 {name=x18}
C {sram6t_tr10.sym} 5730 -4320 0 0 {name=x19}
C {sram6t_tr10.sym} 5730 -4120 0 0 {name=x20}
C {devices/lab_pin.sym} 6370 -4310 1 1 {name=p67 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6780 -4310 1 1 {name=p68 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6370 -4110 1 1 {name=p69 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6780 -4110 1 1 {name=p70 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6360 -4260 1 1 {name=p71 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6770 -4260 1 1 {name=p72 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6360 -4060 1 1 {name=p73 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6770 -4060 1 1 {name=p74 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 6200 -4120 0 0 {name=x21}
C {sram6t_tr10.sym} 6200 -4320 0 0 {name=x22}
C {sram6t_tr10.sym} 6610 -4320 0 0 {name=x23}
C {sram6t_tr10.sym} 6610 -4120 0 0 {name=x24}
C {devices/lab_pin.sym} 7290 -4310 1 1 {name=p75 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7700 -4310 1 1 {name=p76 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7290 -4110 1 1 {name=p77 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7700 -4110 1 1 {name=p78 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7280 -4260 1 1 {name=p79 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7690 -4260 1 1 {name=p80 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7280 -4060 1 1 {name=p81 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7690 -4060 1 1 {name=p82 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 7120 -4120 0 0 {name=x25}
C {sram6t_tr10.sym} 7120 -4320 0 0 {name=x26}
C {sram6t_tr10.sym} 7530 -4320 0 0 {name=x27}
C {sram6t_tr10.sym} 7530 -4120 0 0 {name=x28}
C {devices/lab_pin.sym} 8170 -4310 1 1 {name=p83 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8580 -4310 1 1 {name=p84 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8170 -4110 1 1 {name=p85 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8580 -4110 1 1 {name=p86 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8160 -4260 1 1 {name=p87 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8570 -4260 1 1 {name=p88 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8160 -4060 1 1 {name=p89 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8570 -4060 1 1 {name=p90 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 8000 -4120 0 0 {name=x29}
C {sram6t_tr10.sym} 8000 -4320 0 0 {name=x30}
C {sram6t_tr10.sym} 8410 -4320 0 0 {name=x31}
C {sram6t_tr10.sym} 8410 -4120 0 0 {name=x32}
C {devices/iopin.sym} 5500 -4040 1 0 {name=p93 lab=BL8}
C {devices/iopin.sym} 5520 -4040 1 0 {name=p94 lab=BLB8}
C {devices/iopin.sym} 5910 -4040 1 0 {name=p95 lab=BL9}
C {devices/iopin.sym} 5930 -4040 1 0 {name=p96 lab=BLB9}
C {devices/iopin.sym} 6380 -4040 1 0 {name=p97 lab=BL10}
C {devices/iopin.sym} 6400 -4040 1 0 {name=p98 lab=BLB10}
C {devices/iopin.sym} 6790 -4040 1 0 {name=p99 lab=BL11}
C {devices/iopin.sym} 6810 -4040 1 0 {name=p100 lab=BLB11}
C {devices/iopin.sym} 7300 -4040 1 0 {name=p101 lab=BL12}
C {devices/iopin.sym} 7320 -4040 1 0 {name=p102 lab=BLB12}
C {devices/iopin.sym} 7710 -4040 1 0 {name=p103 lab=BL13}
C {devices/iopin.sym} 7730 -4040 1 0 {name=p104 lab=BLB13}
C {devices/iopin.sym} 8180 -4040 1 0 {name=p105 lab=BL14}
C {devices/iopin.sym} 8200 -4040 1 0 {name=p106 lab=BLB14}
C {devices/iopin.sym} 8590 -4040 1 0 {name=p107 lab=BL15}
C {devices/iopin.sym} 8610 -4040 1 0 {name=p108 lab=BLB15}
C {devices/lab_pin.sym} 1890 -3820 1 1 {name=p49 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2300 -3820 1 1 {name=p50 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1890 -3620 1 1 {name=p109 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2300 -3620 1 1 {name=p110 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1520 -3910 0 0 {name=p111 sig_type=std_logic lab=WL2}
C {devices/lab_pin.sym} 1520 -3710 0 0 {name=p112 sig_type=std_logic lab=WL3}
C {devices/lab_pin.sym} 1880 -3770 1 1 {name=p113 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -3770 1 1 {name=p114 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1880 -3570 1 1 {name=p115 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -3570 1 1 {name=p116 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 1720 -3630 0 0 {name=x33}
C {sram6t_tr10.sym} 1720 -3830 0 0 {name=x34}
C {sram6t_tr10.sym} 2130 -3830 0 0 {name=x35}
C {sram6t_tr10.sym} 2130 -3630 0 0 {name=x36}
C {devices/lab_pin.sym} 2770 -3820 1 1 {name=p117 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3180 -3820 1 1 {name=p118 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2770 -3620 1 1 {name=p119 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3180 -3620 1 1 {name=p120 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2760 -3770 1 1 {name=p121 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3170 -3770 1 1 {name=p122 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2760 -3570 1 1 {name=p123 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3170 -3570 1 1 {name=p124 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 2600 -3630 0 0 {name=x37}
C {sram6t_tr10.sym} 2600 -3830 0 0 {name=x38}
C {sram6t_tr10.sym} 3010 -3830 0 0 {name=x39}
C {sram6t_tr10.sym} 3010 -3630 0 0 {name=x40}
C {devices/lab_pin.sym} 3690 -3820 1 1 {name=p125 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4100 -3820 1 1 {name=p126 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3690 -3620 1 1 {name=p127 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4100 -3620 1 1 {name=p128 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3680 -3770 1 1 {name=p129 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4090 -3770 1 1 {name=p130 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3680 -3570 1 1 {name=p131 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4090 -3570 1 1 {name=p132 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 3520 -3630 0 0 {name=x41}
C {sram6t_tr10.sym} 3520 -3830 0 0 {name=x42}
C {sram6t_tr10.sym} 3930 -3830 0 0 {name=x43}
C {sram6t_tr10.sym} 3930 -3630 0 0 {name=x44}
C {devices/lab_pin.sym} 4570 -3820 1 1 {name=p133 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4980 -3820 1 1 {name=p134 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4570 -3620 1 1 {name=p135 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4980 -3620 1 1 {name=p136 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4560 -3770 1 1 {name=p137 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4970 -3770 1 1 {name=p138 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4560 -3570 1 1 {name=p139 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4970 -3570 1 1 {name=p140 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 4400 -3630 0 0 {name=x45}
C {sram6t_tr10.sym} 4400 -3830 0 0 {name=x46}
C {sram6t_tr10.sym} 4810 -3830 0 0 {name=x47}
C {sram6t_tr10.sym} 4810 -3630 0 0 {name=x48}
C {devices/iopin.sym} 1900 -3550 1 0 {name=p141 lab=BL0}
C {devices/iopin.sym} 1920 -3550 1 0 {name=p142 lab=BLB0}
C {devices/iopin.sym} 2310 -3550 1 0 {name=p143 lab=BL1}
C {devices/iopin.sym} 2330 -3550 1 0 {name=p144 lab=BLB1}
C {devices/iopin.sym} 2780 -3550 1 0 {name=p145 lab=BL2}
C {devices/iopin.sym} 2800 -3550 1 0 {name=p146 lab=BLB2}
C {devices/iopin.sym} 3190 -3550 1 0 {name=p147 lab=BL3}
C {devices/iopin.sym} 3210 -3550 1 0 {name=p148 lab=BLB3}
C {devices/iopin.sym} 3700 -3550 1 0 {name=p149 lab=BL4}
C {devices/iopin.sym} 3720 -3550 1 0 {name=p150 lab=BLB4}
C {devices/iopin.sym} 4110 -3550 1 0 {name=p151 lab=BL5}
C {devices/iopin.sym} 4130 -3550 1 0 {name=p152 lab=BLB5}
C {devices/iopin.sym} 4580 -3550 1 0 {name=p153 lab=BL6}
C {devices/iopin.sym} 4600 -3550 1 0 {name=p154 lab=BLB6}
C {devices/iopin.sym} 4990 -3550 1 0 {name=p155 lab=BL7}
C {devices/iopin.sym} 5010 -3550 1 0 {name=p156 lab=BLB7}
C {devices/lab_pin.sym} 5500 -3820 1 1 {name=p157 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5910 -3820 1 1 {name=p158 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5500 -3620 1 1 {name=p159 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5910 -3620 1 1 {name=p160 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5490 -3770 1 1 {name=p161 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5900 -3770 1 1 {name=p162 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5490 -3570 1 1 {name=p163 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5900 -3570 1 1 {name=p164 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 5330 -3630 0 0 {name=x49}
C {sram6t_tr10.sym} 5330 -3830 0 0 {name=x50}
C {sram6t_tr10.sym} 5740 -3830 0 0 {name=x51}
C {sram6t_tr10.sym} 5740 -3630 0 0 {name=x52}
C {devices/lab_pin.sym} 6380 -3820 1 1 {name=p165 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6790 -3820 1 1 {name=p166 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6380 -3620 1 1 {name=p167 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6790 -3620 1 1 {name=p168 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6370 -3770 1 1 {name=p169 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6780 -3770 1 1 {name=p170 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6370 -3570 1 1 {name=p171 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6780 -3570 1 1 {name=p172 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 6210 -3630 0 0 {name=x53}
C {sram6t_tr10.sym} 6210 -3830 0 0 {name=x54}
C {sram6t_tr10.sym} 6620 -3830 0 0 {name=x55}
C {sram6t_tr10.sym} 6620 -3630 0 0 {name=x56}
C {devices/lab_pin.sym} 7300 -3820 1 1 {name=p173 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7710 -3820 1 1 {name=p174 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7300 -3620 1 1 {name=p175 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7710 -3620 1 1 {name=p176 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7290 -3770 1 1 {name=p177 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7700 -3770 1 1 {name=p178 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7290 -3570 1 1 {name=p179 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7700 -3570 1 1 {name=p180 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 7130 -3630 0 0 {name=x57}
C {sram6t_tr10.sym} 7130 -3830 0 0 {name=x58}
C {sram6t_tr10.sym} 7540 -3830 0 0 {name=x59}
C {sram6t_tr10.sym} 7540 -3630 0 0 {name=x60}
C {devices/lab_pin.sym} 8180 -3820 1 1 {name=p181 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8590 -3820 1 1 {name=p182 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8180 -3620 1 1 {name=p183 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8590 -3620 1 1 {name=p184 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8170 -3770 1 1 {name=p185 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8580 -3770 1 1 {name=p186 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8170 -3570 1 1 {name=p187 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8580 -3570 1 1 {name=p188 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 8010 -3630 0 0 {name=x61}
C {sram6t_tr10.sym} 8010 -3830 0 0 {name=x62}
C {sram6t_tr10.sym} 8420 -3830 0 0 {name=x63}
C {sram6t_tr10.sym} 8420 -3630 0 0 {name=x64}
C {devices/iopin.sym} 5510 -3550 1 0 {name=p189 lab=BL8}
C {devices/iopin.sym} 5530 -3550 1 0 {name=p190 lab=BLB8}
C {devices/iopin.sym} 5920 -3550 1 0 {name=p191 lab=BL9}
C {devices/iopin.sym} 5940 -3550 1 0 {name=p192 lab=BLB9}
C {devices/iopin.sym} 6390 -3550 1 0 {name=p193 lab=BL10}
C {devices/iopin.sym} 6410 -3550 1 0 {name=p194 lab=BLB10}
C {devices/iopin.sym} 6800 -3550 1 0 {name=p195 lab=BL11}
C {devices/iopin.sym} 6820 -3550 1 0 {name=p196 lab=BLB11}
C {devices/iopin.sym} 7310 -3550 1 0 {name=p197 lab=BL12}
C {devices/iopin.sym} 7330 -3550 1 0 {name=p198 lab=BLB12}
C {devices/iopin.sym} 7720 -3550 1 0 {name=p199 lab=BL13}
C {devices/iopin.sym} 7740 -3550 1 0 {name=p200 lab=BLB13}
C {devices/iopin.sym} 8190 -3550 1 0 {name=p201 lab=BL14}
C {devices/iopin.sym} 8210 -3550 1 0 {name=p202 lab=BLB14}
C {devices/iopin.sym} 8600 -3550 1 0 {name=p203 lab=BL15}
C {devices/iopin.sym} 8620 -3550 1 0 {name=p204 lab=BLB15}
C {devices/lab_pin.sym} 1880 -3340 1 1 {name=p205 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2290 -3340 1 1 {name=p206 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1880 -3140 1 1 {name=p207 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2290 -3140 1 1 {name=p208 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1510 -3430 0 0 {name=p209 sig_type=std_logic lab=WL4}
C {devices/lab_pin.sym} 1510 -3230 0 0 {name=p210 sig_type=std_logic lab=WL5}
C {devices/lab_pin.sym} 1870 -3290 1 1 {name=p211 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2280 -3290 1 1 {name=p212 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1870 -3090 1 1 {name=p213 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2280 -3090 1 1 {name=p214 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 1710 -3150 0 0 {name=x65}
C {sram6t_tr10.sym} 1710 -3350 0 0 {name=x66}
C {sram6t_tr10.sym} 2120 -3350 0 0 {name=x67}
C {sram6t_tr10.sym} 2120 -3150 0 0 {name=x68}
C {devices/lab_pin.sym} 2760 -3340 1 1 {name=p215 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3170 -3340 1 1 {name=p216 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2760 -3140 1 1 {name=p217 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3170 -3140 1 1 {name=p218 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2750 -3290 1 1 {name=p219 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3160 -3290 1 1 {name=p220 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2750 -3090 1 1 {name=p221 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3160 -3090 1 1 {name=p222 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 2590 -3150 0 0 {name=x69}
C {sram6t_tr10.sym} 2590 -3350 0 0 {name=x70}
C {sram6t_tr10.sym} 3000 -3350 0 0 {name=x71}
C {sram6t_tr10.sym} 3000 -3150 0 0 {name=x72}
C {devices/lab_pin.sym} 3680 -3340 1 1 {name=p223 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4090 -3340 1 1 {name=p224 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3680 -3140 1 1 {name=p225 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4090 -3140 1 1 {name=p226 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3670 -3290 1 1 {name=p227 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4080 -3290 1 1 {name=p228 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3670 -3090 1 1 {name=p229 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4080 -3090 1 1 {name=p230 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 3510 -3150 0 0 {name=x73}
C {sram6t_tr10.sym} 3510 -3350 0 0 {name=x74}
C {sram6t_tr10.sym} 3920 -3350 0 0 {name=x75}
C {sram6t_tr10.sym} 3920 -3150 0 0 {name=x76}
C {devices/lab_pin.sym} 4560 -3340 1 1 {name=p231 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4970 -3340 1 1 {name=p232 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4560 -3140 1 1 {name=p233 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4970 -3140 1 1 {name=p234 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4550 -3290 1 1 {name=p235 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4960 -3290 1 1 {name=p236 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4550 -3090 1 1 {name=p237 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4960 -3090 1 1 {name=p238 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 4390 -3150 0 0 {name=x77}
C {sram6t_tr10.sym} 4390 -3350 0 0 {name=x78}
C {sram6t_tr10.sym} 4800 -3350 0 0 {name=x79}
C {sram6t_tr10.sym} 4800 -3150 0 0 {name=x80}
C {devices/iopin.sym} 1890 -3070 1 0 {name=p239 lab=BL0}
C {devices/iopin.sym} 1910 -3070 1 0 {name=p240 lab=BLB0}
C {devices/iopin.sym} 2300 -3070 1 0 {name=p241 lab=BL1}
C {devices/iopin.sym} 2320 -3070 1 0 {name=p242 lab=BLB1}
C {devices/iopin.sym} 2770 -3070 1 0 {name=p243 lab=BL2}
C {devices/iopin.sym} 2790 -3070 1 0 {name=p244 lab=BLB2}
C {devices/iopin.sym} 3180 -3070 1 0 {name=p245 lab=BL3}
C {devices/iopin.sym} 3200 -3070 1 0 {name=p246 lab=BLB3}
C {devices/iopin.sym} 3690 -3070 1 0 {name=p247 lab=BL4}
C {devices/iopin.sym} 3710 -3070 1 0 {name=p248 lab=BLB4}
C {devices/iopin.sym} 4100 -3070 1 0 {name=p249 lab=BL5}
C {devices/iopin.sym} 4120 -3070 1 0 {name=p250 lab=BLB5}
C {devices/iopin.sym} 4570 -3070 1 0 {name=p251 lab=BL6}
C {devices/iopin.sym} 4590 -3070 1 0 {name=p252 lab=BLB6}
C {devices/iopin.sym} 4980 -3070 1 0 {name=p253 lab=BL7}
C {devices/iopin.sym} 5000 -3070 1 0 {name=p254 lab=BLB7}
C {devices/lab_pin.sym} 5490 -3340 1 1 {name=p255 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5900 -3340 1 1 {name=p256 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5490 -3140 1 1 {name=p257 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5900 -3140 1 1 {name=p258 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5480 -3290 1 1 {name=p259 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5890 -3290 1 1 {name=p260 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5480 -3090 1 1 {name=p261 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5890 -3090 1 1 {name=p262 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 5320 -3150 0 0 {name=x81}
C {sram6t_tr10.sym} 5320 -3350 0 0 {name=x82}
C {sram6t_tr10.sym} 5730 -3350 0 0 {name=x83}
C {sram6t_tr10.sym} 5730 -3150 0 0 {name=x84}
C {devices/lab_pin.sym} 6370 -3340 1 1 {name=p263 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6780 -3340 1 1 {name=p264 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6370 -3140 1 1 {name=p265 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6780 -3140 1 1 {name=p266 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6360 -3290 1 1 {name=p267 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6770 -3290 1 1 {name=p268 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6360 -3090 1 1 {name=p269 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6770 -3090 1 1 {name=p270 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 6200 -3150 0 0 {name=x85}
C {sram6t_tr10.sym} 6200 -3350 0 0 {name=x86}
C {sram6t_tr10.sym} 6610 -3350 0 0 {name=x87}
C {sram6t_tr10.sym} 6610 -3150 0 0 {name=x88}
C {devices/lab_pin.sym} 7290 -3340 1 1 {name=p271 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7700 -3340 1 1 {name=p272 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7290 -3140 1 1 {name=p273 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7700 -3140 1 1 {name=p274 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7280 -3290 1 1 {name=p275 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7690 -3290 1 1 {name=p276 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7280 -3090 1 1 {name=p277 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7690 -3090 1 1 {name=p278 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 7120 -3150 0 0 {name=x89}
C {sram6t_tr10.sym} 7120 -3350 0 0 {name=x90}
C {sram6t_tr10.sym} 7530 -3350 0 0 {name=x91}
C {sram6t_tr10.sym} 7530 -3150 0 0 {name=x92}
C {devices/lab_pin.sym} 8170 -3340 1 1 {name=p279 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8580 -3340 1 1 {name=p280 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8170 -3140 1 1 {name=p281 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8580 -3140 1 1 {name=p282 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8160 -3290 1 1 {name=p283 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8570 -3290 1 1 {name=p284 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8160 -3090 1 1 {name=p285 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8570 -3090 1 1 {name=p286 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 8000 -3150 0 0 {name=x93}
C {sram6t_tr10.sym} 8000 -3350 0 0 {name=x94}
C {sram6t_tr10.sym} 8410 -3350 0 0 {name=x95}
C {sram6t_tr10.sym} 8410 -3150 0 0 {name=x96}
C {devices/iopin.sym} 5500 -3070 1 0 {name=p287 lab=BL8}
C {devices/iopin.sym} 5520 -3070 1 0 {name=p288 lab=BLB8}
C {devices/iopin.sym} 5910 -3070 1 0 {name=p289 lab=BL9}
C {devices/iopin.sym} 5930 -3070 1 0 {name=p290 lab=BLB9}
C {devices/iopin.sym} 6380 -3070 1 0 {name=p291 lab=BL10}
C {devices/iopin.sym} 6400 -3070 1 0 {name=p292 lab=BLB10}
C {devices/iopin.sym} 6790 -3070 1 0 {name=p293 lab=BL11}
C {devices/iopin.sym} 6810 -3070 1 0 {name=p294 lab=BLB11}
C {devices/iopin.sym} 7300 -3070 1 0 {name=p295 lab=BL12}
C {devices/iopin.sym} 7320 -3070 1 0 {name=p296 lab=BLB12}
C {devices/iopin.sym} 7710 -3070 1 0 {name=p297 lab=BL13}
C {devices/iopin.sym} 7730 -3070 1 0 {name=p298 lab=BLB13}
C {devices/iopin.sym} 8180 -3070 1 0 {name=p299 lab=BL14}
C {devices/iopin.sym} 8200 -3070 1 0 {name=p300 lab=BLB14}
C {devices/iopin.sym} 8590 -3070 1 0 {name=p301 lab=BL15}
C {devices/iopin.sym} 8610 -3070 1 0 {name=p302 lab=BLB15}
C {devices/lab_pin.sym} 1890 -2850 1 1 {name=p303 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2300 -2850 1 1 {name=p304 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1890 -2650 1 1 {name=p305 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2300 -2650 1 1 {name=p306 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1520 -2940 0 0 {name=p307 sig_type=std_logic lab=WL6}
C {devices/lab_pin.sym} 1520 -2740 0 0 {name=p308 sig_type=std_logic lab=WL7}
C {devices/lab_pin.sym} 1880 -2800 1 1 {name=p309 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -2800 1 1 {name=p310 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1880 -2600 1 1 {name=p311 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -2600 1 1 {name=p312 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 1720 -2660 0 0 {name=x97}
C {sram6t_tr10.sym} 1720 -2860 0 0 {name=x98}
C {sram6t_tr10.sym} 2130 -2860 0 0 {name=x99}
C {sram6t_tr10.sym} 2130 -2660 0 0 {name=x100}
C {devices/lab_pin.sym} 2770 -2850 1 1 {name=p313 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3180 -2850 1 1 {name=p314 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2770 -2650 1 1 {name=p315 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3180 -2650 1 1 {name=p316 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2760 -2800 1 1 {name=p317 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3170 -2800 1 1 {name=p318 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2760 -2600 1 1 {name=p319 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3170 -2600 1 1 {name=p320 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 2600 -2660 0 0 {name=x101}
C {sram6t_tr10.sym} 2600 -2860 0 0 {name=x102}
C {sram6t_tr10.sym} 3010 -2860 0 0 {name=x103}
C {sram6t_tr10.sym} 3010 -2660 0 0 {name=x104}
C {devices/lab_pin.sym} 3690 -2850 1 1 {name=p321 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4100 -2850 1 1 {name=p322 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3690 -2650 1 1 {name=p323 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4100 -2650 1 1 {name=p324 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3680 -2800 1 1 {name=p325 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4090 -2800 1 1 {name=p326 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3680 -2600 1 1 {name=p327 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4090 -2600 1 1 {name=p328 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 3520 -2660 0 0 {name=x105}
C {sram6t_tr10.sym} 3520 -2860 0 0 {name=x106}
C {sram6t_tr10.sym} 3930 -2860 0 0 {name=x107}
C {sram6t_tr10.sym} 3930 -2660 0 0 {name=x108}
C {devices/lab_pin.sym} 4570 -2850 1 1 {name=p329 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4980 -2850 1 1 {name=p330 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4570 -2650 1 1 {name=p331 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4980 -2650 1 1 {name=p332 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4560 -2800 1 1 {name=p333 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4970 -2800 1 1 {name=p334 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4560 -2600 1 1 {name=p335 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4970 -2600 1 1 {name=p336 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 4400 -2660 0 0 {name=x109}
C {sram6t_tr10.sym} 4400 -2860 0 0 {name=x110}
C {sram6t_tr10.sym} 4810 -2860 0 0 {name=x111}
C {sram6t_tr10.sym} 4810 -2660 0 0 {name=x112}
C {devices/iopin.sym} 1900 -2580 1 0 {name=p337 lab=BL0}
C {devices/iopin.sym} 1920 -2580 1 0 {name=p338 lab=BLB0}
C {devices/iopin.sym} 2310 -2580 1 0 {name=p339 lab=BL1}
C {devices/iopin.sym} 2330 -2580 1 0 {name=p340 lab=BLB1}
C {devices/iopin.sym} 2780 -2580 1 0 {name=p341 lab=BL2}
C {devices/iopin.sym} 2800 -2580 1 0 {name=p342 lab=BLB2}
C {devices/iopin.sym} 3190 -2580 1 0 {name=p343 lab=BL3}
C {devices/iopin.sym} 3210 -2580 1 0 {name=p344 lab=BLB3}
C {devices/iopin.sym} 3700 -2580 1 0 {name=p345 lab=BL4}
C {devices/iopin.sym} 3720 -2580 1 0 {name=p346 lab=BLB4}
C {devices/iopin.sym} 4110 -2580 1 0 {name=p347 lab=BL5}
C {devices/iopin.sym} 4130 -2580 1 0 {name=p348 lab=BLB5}
C {devices/iopin.sym} 4580 -2580 1 0 {name=p349 lab=BL6}
C {devices/iopin.sym} 4600 -2580 1 0 {name=p350 lab=BLB6}
C {devices/iopin.sym} 4990 -2580 1 0 {name=p351 lab=BL7}
C {devices/iopin.sym} 5010 -2580 1 0 {name=p352 lab=BLB7}
C {devices/lab_pin.sym} 5500 -2850 1 1 {name=p353 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5910 -2850 1 1 {name=p354 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5500 -2650 1 1 {name=p355 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5910 -2650 1 1 {name=p356 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5490 -2800 1 1 {name=p357 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5900 -2800 1 1 {name=p358 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5490 -2600 1 1 {name=p359 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5900 -2600 1 1 {name=p360 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 5330 -2660 0 0 {name=x113}
C {sram6t_tr10.sym} 5330 -2860 0 0 {name=x114}
C {sram6t_tr10.sym} 5740 -2860 0 0 {name=x115}
C {sram6t_tr10.sym} 5740 -2660 0 0 {name=x116}
C {devices/lab_pin.sym} 6380 -2850 1 1 {name=p361 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6790 -2850 1 1 {name=p362 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6380 -2650 1 1 {name=p363 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6790 -2650 1 1 {name=p364 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6370 -2800 1 1 {name=p365 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6780 -2800 1 1 {name=p366 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6370 -2600 1 1 {name=p367 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6780 -2600 1 1 {name=p368 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 6210 -2660 0 0 {name=x117}
C {sram6t_tr10.sym} 6210 -2860 0 0 {name=x118}
C {sram6t_tr10.sym} 6620 -2860 0 0 {name=x119}
C {sram6t_tr10.sym} 6620 -2660 0 0 {name=x120}
C {devices/lab_pin.sym} 7300 -2850 1 1 {name=p369 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7710 -2850 1 1 {name=p370 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7300 -2650 1 1 {name=p371 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7710 -2650 1 1 {name=p372 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7290 -2800 1 1 {name=p373 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7700 -2800 1 1 {name=p374 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7290 -2600 1 1 {name=p375 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7700 -2600 1 1 {name=p376 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 7130 -2660 0 0 {name=x121}
C {sram6t_tr10.sym} 7130 -2860 0 0 {name=x122}
C {sram6t_tr10.sym} 7540 -2860 0 0 {name=x123}
C {sram6t_tr10.sym} 7540 -2660 0 0 {name=x124}
C {devices/lab_pin.sym} 8180 -2850 1 1 {name=p377 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8590 -2850 1 1 {name=p378 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8180 -2650 1 1 {name=p379 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8590 -2650 1 1 {name=p380 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8170 -2800 1 1 {name=p381 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8580 -2800 1 1 {name=p382 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8170 -2600 1 1 {name=p383 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8580 -2600 1 1 {name=p384 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 8010 -2660 0 0 {name=x125}
C {sram6t_tr10.sym} 8010 -2860 0 0 {name=x126}
C {sram6t_tr10.sym} 8420 -2860 0 0 {name=x127}
C {sram6t_tr10.sym} 8420 -2660 0 0 {name=x128}
C {devices/iopin.sym} 5510 -2580 1 0 {name=p385 lab=BL8}
C {devices/iopin.sym} 5530 -2580 1 0 {name=p386 lab=BLB8}
C {devices/iopin.sym} 5920 -2580 1 0 {name=p387 lab=BL9}
C {devices/iopin.sym} 5940 -2580 1 0 {name=p388 lab=BLB9}
C {devices/iopin.sym} 6390 -2580 1 0 {name=p389 lab=BL10}
C {devices/iopin.sym} 6410 -2580 1 0 {name=p390 lab=BLB10}
C {devices/iopin.sym} 6800 -2580 1 0 {name=p391 lab=BL11}
C {devices/iopin.sym} 6820 -2580 1 0 {name=p392 lab=BLB11}
C {devices/iopin.sym} 7310 -2580 1 0 {name=p393 lab=BL12}
C {devices/iopin.sym} 7330 -2580 1 0 {name=p394 lab=BLB12}
C {devices/iopin.sym} 7720 -2580 1 0 {name=p395 lab=BL13}
C {devices/iopin.sym} 7740 -2580 1 0 {name=p396 lab=BLB13}
C {devices/iopin.sym} 8190 -2580 1 0 {name=p397 lab=BL14}
C {devices/iopin.sym} 8210 -2580 1 0 {name=p398 lab=BLB14}
C {devices/iopin.sym} 8600 -2580 1 0 {name=p399 lab=BL15}
C {devices/iopin.sym} 8620 -2580 1 0 {name=p400 lab=BLB15}
C {devices/lab_pin.sym} 1860 -2360 1 1 {name=p401 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2270 -2360 1 1 {name=p402 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1860 -2160 1 1 {name=p403 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2270 -2160 1 1 {name=p404 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1490 -2450 0 0 {name=p405 sig_type=std_logic lab=WL8}
C {devices/lab_pin.sym} 1490 -2250 0 0 {name=p406 sig_type=std_logic lab=WL9}
C {devices/lab_pin.sym} 1850 -2310 1 1 {name=p407 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2260 -2310 1 1 {name=p408 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1850 -2110 1 1 {name=p409 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2260 -2110 1 1 {name=p410 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 1690 -2170 0 0 {name=x129}
C {sram6t_tr10.sym} 1690 -2370 0 0 {name=x130}
C {sram6t_tr10.sym} 2100 -2370 0 0 {name=x131}
C {sram6t_tr10.sym} 2100 -2170 0 0 {name=x132}
C {devices/lab_pin.sym} 2740 -2360 1 1 {name=p411 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3150 -2360 1 1 {name=p412 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2740 -2160 1 1 {name=p413 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3150 -2160 1 1 {name=p414 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2730 -2310 1 1 {name=p415 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3140 -2310 1 1 {name=p416 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2730 -2110 1 1 {name=p417 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3140 -2110 1 1 {name=p418 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 2570 -2170 0 0 {name=x133}
C {sram6t_tr10.sym} 2570 -2370 0 0 {name=x134}
C {sram6t_tr10.sym} 2980 -2370 0 0 {name=x135}
C {sram6t_tr10.sym} 2980 -2170 0 0 {name=x136}
C {devices/lab_pin.sym} 3660 -2360 1 1 {name=p419 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4070 -2360 1 1 {name=p420 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3660 -2160 1 1 {name=p421 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4070 -2160 1 1 {name=p422 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3650 -2310 1 1 {name=p423 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4060 -2310 1 1 {name=p424 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3650 -2110 1 1 {name=p425 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4060 -2110 1 1 {name=p426 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 3490 -2170 0 0 {name=x137}
C {sram6t_tr10.sym} 3490 -2370 0 0 {name=x138}
C {sram6t_tr10.sym} 3900 -2370 0 0 {name=x139}
C {sram6t_tr10.sym} 3900 -2170 0 0 {name=x140}
C {devices/lab_pin.sym} 4540 -2360 1 1 {name=p427 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4950 -2360 1 1 {name=p428 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4540 -2160 1 1 {name=p429 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4950 -2160 1 1 {name=p430 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4530 -2310 1 1 {name=p431 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4940 -2310 1 1 {name=p432 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4530 -2110 1 1 {name=p433 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4940 -2110 1 1 {name=p434 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 4370 -2170 0 0 {name=x141}
C {sram6t_tr10.sym} 4370 -2370 0 0 {name=x142}
C {sram6t_tr10.sym} 4780 -2370 0 0 {name=x143}
C {sram6t_tr10.sym} 4780 -2170 0 0 {name=x144}
C {devices/iopin.sym} 1870 -2090 1 0 {name=p435 lab=BL0}
C {devices/iopin.sym} 1890 -2090 1 0 {name=p436 lab=BLB0}
C {devices/iopin.sym} 2280 -2090 1 0 {name=p437 lab=BL1}
C {devices/iopin.sym} 2300 -2090 1 0 {name=p438 lab=BLB1}
C {devices/iopin.sym} 2750 -2090 1 0 {name=p439 lab=BL2}
C {devices/iopin.sym} 2770 -2090 1 0 {name=p440 lab=BLB2}
C {devices/iopin.sym} 3160 -2090 1 0 {name=p441 lab=BL3}
C {devices/iopin.sym} 3180 -2090 1 0 {name=p442 lab=BLB3}
C {devices/iopin.sym} 3670 -2090 1 0 {name=p443 lab=BL4}
C {devices/iopin.sym} 3690 -2090 1 0 {name=p444 lab=BLB4}
C {devices/iopin.sym} 4080 -2090 1 0 {name=p445 lab=BL5}
C {devices/iopin.sym} 4100 -2090 1 0 {name=p446 lab=BLB5}
C {devices/iopin.sym} 4550 -2090 1 0 {name=p447 lab=BL6}
C {devices/iopin.sym} 4570 -2090 1 0 {name=p448 lab=BLB6}
C {devices/iopin.sym} 4960 -2090 1 0 {name=p449 lab=BL7}
C {devices/iopin.sym} 4980 -2090 1 0 {name=p450 lab=BLB7}
C {devices/lab_pin.sym} 5470 -2360 1 1 {name=p451 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5880 -2360 1 1 {name=p452 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5470 -2160 1 1 {name=p453 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5880 -2160 1 1 {name=p454 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5460 -2310 1 1 {name=p455 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5870 -2310 1 1 {name=p456 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5460 -2110 1 1 {name=p457 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5870 -2110 1 1 {name=p458 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 5300 -2170 0 0 {name=x145}
C {sram6t_tr10.sym} 5300 -2370 0 0 {name=x146}
C {sram6t_tr10.sym} 5710 -2370 0 0 {name=x147}
C {sram6t_tr10.sym} 5710 -2170 0 0 {name=x148}
C {devices/lab_pin.sym} 6350 -2360 1 1 {name=p459 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6760 -2360 1 1 {name=p460 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6350 -2160 1 1 {name=p461 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6760 -2160 1 1 {name=p462 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6340 -2310 1 1 {name=p463 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6750 -2310 1 1 {name=p464 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6340 -2110 1 1 {name=p465 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6750 -2110 1 1 {name=p466 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 6180 -2170 0 0 {name=x149}
C {sram6t_tr10.sym} 6180 -2370 0 0 {name=x150}
C {sram6t_tr10.sym} 6590 -2370 0 0 {name=x151}
C {sram6t_tr10.sym} 6590 -2170 0 0 {name=x152}
C {devices/lab_pin.sym} 7270 -2360 1 1 {name=p467 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7680 -2360 1 1 {name=p468 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7270 -2160 1 1 {name=p469 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7680 -2160 1 1 {name=p470 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7260 -2310 1 1 {name=p471 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7670 -2310 1 1 {name=p472 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7260 -2110 1 1 {name=p473 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7670 -2110 1 1 {name=p474 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 7100 -2170 0 0 {name=x153}
C {sram6t_tr10.sym} 7100 -2370 0 0 {name=x154}
C {sram6t_tr10.sym} 7510 -2370 0 0 {name=x155}
C {sram6t_tr10.sym} 7510 -2170 0 0 {name=x156}
C {devices/lab_pin.sym} 8150 -2360 1 1 {name=p475 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8560 -2360 1 1 {name=p476 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8150 -2160 1 1 {name=p477 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8560 -2160 1 1 {name=p478 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8140 -2310 1 1 {name=p479 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8550 -2310 1 1 {name=p480 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8140 -2110 1 1 {name=p481 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8550 -2110 1 1 {name=p482 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 7980 -2170 0 0 {name=x157}
C {sram6t_tr10.sym} 7980 -2370 0 0 {name=x158}
C {sram6t_tr10.sym} 8390 -2370 0 0 {name=x159}
C {sram6t_tr10.sym} 8390 -2170 0 0 {name=x160}
C {devices/iopin.sym} 5480 -2090 1 0 {name=p483 lab=BL8}
C {devices/iopin.sym} 5500 -2090 1 0 {name=p484 lab=BLB8}
C {devices/iopin.sym} 5890 -2090 1 0 {name=p485 lab=BL9}
C {devices/iopin.sym} 5910 -2090 1 0 {name=p486 lab=BLB9}
C {devices/iopin.sym} 6360 -2090 1 0 {name=p487 lab=BL10}
C {devices/iopin.sym} 6380 -2090 1 0 {name=p488 lab=BLB10}
C {devices/iopin.sym} 6770 -2090 1 0 {name=p489 lab=BL11}
C {devices/iopin.sym} 6790 -2090 1 0 {name=p490 lab=BLB11}
C {devices/iopin.sym} 7280 -2090 1 0 {name=p491 lab=BL12}
C {devices/iopin.sym} 7300 -2090 1 0 {name=p492 lab=BLB12}
C {devices/iopin.sym} 7690 -2090 1 0 {name=p493 lab=BL13}
C {devices/iopin.sym} 7710 -2090 1 0 {name=p494 lab=BLB13}
C {devices/iopin.sym} 8160 -2090 1 0 {name=p495 lab=BL14}
C {devices/iopin.sym} 8180 -2090 1 0 {name=p496 lab=BLB14}
C {devices/iopin.sym} 8570 -2090 1 0 {name=p497 lab=BL15}
C {devices/iopin.sym} 8590 -2090 1 0 {name=p498 lab=BLB15}
C {devices/lab_pin.sym} 1870 -1870 1 1 {name=p499 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2280 -1870 1 1 {name=p500 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1870 -1670 1 1 {name=p501 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2280 -1670 1 1 {name=p502 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1500 -1960 0 0 {name=p503 sig_type=std_logic lab=WL10}
C {devices/lab_pin.sym} 1500 -1760 0 0 {name=p504 sig_type=std_logic lab=WL11}
C {devices/lab_pin.sym} 1860 -1820 1 1 {name=p505 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2270 -1820 1 1 {name=p506 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1860 -1620 1 1 {name=p507 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2270 -1620 1 1 {name=p508 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 1700 -1680 0 0 {name=x161}
C {sram6t_tr10.sym} 1700 -1880 0 0 {name=x162}
C {sram6t_tr10.sym} 2110 -1880 0 0 {name=x163}
C {sram6t_tr10.sym} 2110 -1680 0 0 {name=x164}
C {devices/lab_pin.sym} 2750 -1870 1 1 {name=p509 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3160 -1870 1 1 {name=p510 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2750 -1670 1 1 {name=p511 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3160 -1670 1 1 {name=p512 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2740 -1820 1 1 {name=p513 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3150 -1820 1 1 {name=p514 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2740 -1620 1 1 {name=p515 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3150 -1620 1 1 {name=p516 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 2580 -1680 0 0 {name=x165}
C {sram6t_tr10.sym} 2580 -1880 0 0 {name=x166}
C {sram6t_tr10.sym} 2990 -1880 0 0 {name=x167}
C {sram6t_tr10.sym} 2990 -1680 0 0 {name=x168}
C {devices/lab_pin.sym} 3670 -1870 1 1 {name=p517 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4080 -1870 1 1 {name=p518 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3670 -1670 1 1 {name=p519 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4080 -1670 1 1 {name=p520 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3660 -1820 1 1 {name=p521 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4070 -1820 1 1 {name=p522 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3660 -1620 1 1 {name=p523 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4070 -1620 1 1 {name=p524 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 3500 -1680 0 0 {name=x169}
C {sram6t_tr10.sym} 3500 -1880 0 0 {name=x170}
C {sram6t_tr10.sym} 3910 -1880 0 0 {name=x171}
C {sram6t_tr10.sym} 3910 -1680 0 0 {name=x172}
C {devices/lab_pin.sym} 4550 -1870 1 1 {name=p525 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4960 -1870 1 1 {name=p526 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4550 -1670 1 1 {name=p527 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4960 -1670 1 1 {name=p528 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4540 -1820 1 1 {name=p529 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4950 -1820 1 1 {name=p530 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4540 -1620 1 1 {name=p531 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4950 -1620 1 1 {name=p532 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 4380 -1680 0 0 {name=x173}
C {sram6t_tr10.sym} 4380 -1880 0 0 {name=x174}
C {sram6t_tr10.sym} 4790 -1880 0 0 {name=x175}
C {sram6t_tr10.sym} 4790 -1680 0 0 {name=x176}
C {devices/iopin.sym} 1880 -1600 1 0 {name=p533 lab=BL0}
C {devices/iopin.sym} 1900 -1600 1 0 {name=p534 lab=BLB0}
C {devices/iopin.sym} 2290 -1600 1 0 {name=p535 lab=BL1}
C {devices/iopin.sym} 2310 -1600 1 0 {name=p536 lab=BLB1}
C {devices/iopin.sym} 2760 -1600 1 0 {name=p537 lab=BL2}
C {devices/iopin.sym} 2780 -1600 1 0 {name=p538 lab=BLB2}
C {devices/iopin.sym} 3170 -1600 1 0 {name=p539 lab=BL3}
C {devices/iopin.sym} 3190 -1600 1 0 {name=p540 lab=BLB3}
C {devices/iopin.sym} 3680 -1600 1 0 {name=p541 lab=BL4}
C {devices/iopin.sym} 3700 -1600 1 0 {name=p542 lab=BLB4}
C {devices/iopin.sym} 4090 -1600 1 0 {name=p543 lab=BL5}
C {devices/iopin.sym} 4110 -1600 1 0 {name=p544 lab=BLB5}
C {devices/iopin.sym} 4560 -1600 1 0 {name=p545 lab=BL6}
C {devices/iopin.sym} 4580 -1600 1 0 {name=p546 lab=BLB6}
C {devices/iopin.sym} 4970 -1600 1 0 {name=p547 lab=BL7}
C {devices/iopin.sym} 4990 -1600 1 0 {name=p548 lab=BLB7}
C {devices/lab_pin.sym} 5480 -1870 1 1 {name=p549 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5890 -1870 1 1 {name=p550 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5480 -1670 1 1 {name=p551 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5890 -1670 1 1 {name=p552 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5470 -1820 1 1 {name=p553 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5880 -1820 1 1 {name=p554 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5470 -1620 1 1 {name=p555 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5880 -1620 1 1 {name=p556 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 5310 -1680 0 0 {name=x177}
C {sram6t_tr10.sym} 5310 -1880 0 0 {name=x178}
C {sram6t_tr10.sym} 5720 -1880 0 0 {name=x179}
C {sram6t_tr10.sym} 5720 -1680 0 0 {name=x180}
C {devices/lab_pin.sym} 6360 -1870 1 1 {name=p557 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6770 -1870 1 1 {name=p558 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6360 -1670 1 1 {name=p559 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6770 -1670 1 1 {name=p560 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6350 -1820 1 1 {name=p561 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6760 -1820 1 1 {name=p562 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6350 -1620 1 1 {name=p563 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6760 -1620 1 1 {name=p564 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 6190 -1680 0 0 {name=x181}
C {sram6t_tr10.sym} 6190 -1880 0 0 {name=x182}
C {sram6t_tr10.sym} 6600 -1880 0 0 {name=x183}
C {sram6t_tr10.sym} 6600 -1680 0 0 {name=x184}
C {devices/lab_pin.sym} 7280 -1870 1 1 {name=p565 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7690 -1870 1 1 {name=p566 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7280 -1670 1 1 {name=p567 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7690 -1670 1 1 {name=p568 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7270 -1820 1 1 {name=p569 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7680 -1820 1 1 {name=p570 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7270 -1620 1 1 {name=p571 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7680 -1620 1 1 {name=p572 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 7110 -1680 0 0 {name=x185}
C {sram6t_tr10.sym} 7110 -1880 0 0 {name=x186}
C {sram6t_tr10.sym} 7520 -1880 0 0 {name=x187}
C {sram6t_tr10.sym} 7520 -1680 0 0 {name=x188}
C {devices/lab_pin.sym} 8160 -1870 1 1 {name=p573 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8570 -1870 1 1 {name=p574 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8160 -1670 1 1 {name=p575 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8570 -1670 1 1 {name=p576 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8150 -1820 1 1 {name=p577 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8560 -1820 1 1 {name=p578 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8150 -1620 1 1 {name=p579 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8560 -1620 1 1 {name=p580 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 7990 -1680 0 0 {name=x189}
C {sram6t_tr10.sym} 7990 -1880 0 0 {name=x190}
C {sram6t_tr10.sym} 8400 -1880 0 0 {name=x191}
C {sram6t_tr10.sym} 8400 -1680 0 0 {name=x192}
C {devices/iopin.sym} 5490 -1600 1 0 {name=p581 lab=BL8}
C {devices/iopin.sym} 5510 -1600 1 0 {name=p582 lab=BLB8}
C {devices/iopin.sym} 5900 -1600 1 0 {name=p583 lab=BL9}
C {devices/iopin.sym} 5920 -1600 1 0 {name=p584 lab=BLB9}
C {devices/iopin.sym} 6370 -1600 1 0 {name=p585 lab=BL10}
C {devices/iopin.sym} 6390 -1600 1 0 {name=p586 lab=BLB10}
C {devices/iopin.sym} 6780 -1600 1 0 {name=p587 lab=BL11}
C {devices/iopin.sym} 6800 -1600 1 0 {name=p588 lab=BLB11}
C {devices/iopin.sym} 7290 -1600 1 0 {name=p589 lab=BL12}
C {devices/iopin.sym} 7310 -1600 1 0 {name=p590 lab=BLB12}
C {devices/iopin.sym} 7700 -1600 1 0 {name=p591 lab=BL13}
C {devices/iopin.sym} 7720 -1600 1 0 {name=p592 lab=BLB13}
C {devices/iopin.sym} 8170 -1600 1 0 {name=p593 lab=BL14}
C {devices/iopin.sym} 8190 -1600 1 0 {name=p594 lab=BLB14}
C {devices/iopin.sym} 8580 -1600 1 0 {name=p595 lab=BL15}
C {devices/iopin.sym} 8600 -1600 1 0 {name=p596 lab=BLB15}
C {devices/lab_pin.sym} 1860 -1390 1 1 {name=p597 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2270 -1390 1 1 {name=p598 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1860 -1190 1 1 {name=p599 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2270 -1190 1 1 {name=p600 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1490 -1480 0 0 {name=p601 sig_type=std_logic lab=WL12}
C {devices/lab_pin.sym} 1490 -1280 0 0 {name=p602 sig_type=std_logic lab=WL13}
C {devices/lab_pin.sym} 1850 -1340 1 1 {name=p603 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2260 -1340 1 1 {name=p604 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1850 -1140 1 1 {name=p605 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2260 -1140 1 1 {name=p606 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 1690 -1200 0 0 {name=x193}
C {sram6t_tr10.sym} 1690 -1400 0 0 {name=x194}
C {sram6t_tr10.sym} 2100 -1400 0 0 {name=x195}
C {sram6t_tr10.sym} 2100 -1200 0 0 {name=x196}
C {devices/lab_pin.sym} 2740 -1390 1 1 {name=p607 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3150 -1390 1 1 {name=p608 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2740 -1190 1 1 {name=p609 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3150 -1190 1 1 {name=p610 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2730 -1340 1 1 {name=p611 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3140 -1340 1 1 {name=p612 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2730 -1140 1 1 {name=p613 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3140 -1140 1 1 {name=p614 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 2570 -1200 0 0 {name=x197}
C {sram6t_tr10.sym} 2570 -1400 0 0 {name=x198}
C {sram6t_tr10.sym} 2980 -1400 0 0 {name=x199}
C {sram6t_tr10.sym} 2980 -1200 0 0 {name=x200}
C {devices/lab_pin.sym} 3660 -1390 1 1 {name=p615 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4070 -1390 1 1 {name=p616 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3660 -1190 1 1 {name=p617 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4070 -1190 1 1 {name=p618 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3650 -1340 1 1 {name=p619 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4060 -1340 1 1 {name=p620 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3650 -1140 1 1 {name=p621 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4060 -1140 1 1 {name=p622 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 3490 -1200 0 0 {name=x201}
C {sram6t_tr10.sym} 3490 -1400 0 0 {name=x202}
C {sram6t_tr10.sym} 3900 -1400 0 0 {name=x203}
C {sram6t_tr10.sym} 3900 -1200 0 0 {name=x204}
C {devices/lab_pin.sym} 4540 -1390 1 1 {name=p623 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4950 -1390 1 1 {name=p624 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4540 -1190 1 1 {name=p625 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4950 -1190 1 1 {name=p626 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4530 -1340 1 1 {name=p627 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4940 -1340 1 1 {name=p628 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4530 -1140 1 1 {name=p629 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4940 -1140 1 1 {name=p630 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 4370 -1200 0 0 {name=x205}
C {sram6t_tr10.sym} 4370 -1400 0 0 {name=x206}
C {sram6t_tr10.sym} 4780 -1400 0 0 {name=x207}
C {sram6t_tr10.sym} 4780 -1200 0 0 {name=x208}
C {devices/iopin.sym} 1870 -1120 1 0 {name=p631 lab=BL0}
C {devices/iopin.sym} 1890 -1120 1 0 {name=p632 lab=BLB0}
C {devices/iopin.sym} 2280 -1120 1 0 {name=p633 lab=BL1}
C {devices/iopin.sym} 2300 -1120 1 0 {name=p634 lab=BLB1}
C {devices/iopin.sym} 2750 -1120 1 0 {name=p635 lab=BL2}
C {devices/iopin.sym} 2770 -1120 1 0 {name=p636 lab=BLB2}
C {devices/iopin.sym} 3160 -1120 1 0 {name=p637 lab=BL3}
C {devices/iopin.sym} 3180 -1120 1 0 {name=p638 lab=BLB3}
C {devices/iopin.sym} 3670 -1120 1 0 {name=p639 lab=BL4}
C {devices/iopin.sym} 3690 -1120 1 0 {name=p640 lab=BLB4}
C {devices/iopin.sym} 4080 -1120 1 0 {name=p641 lab=BL5}
C {devices/iopin.sym} 4100 -1120 1 0 {name=p642 lab=BLB5}
C {devices/iopin.sym} 4550 -1120 1 0 {name=p643 lab=BL6}
C {devices/iopin.sym} 4570 -1120 1 0 {name=p644 lab=BLB6}
C {devices/iopin.sym} 4960 -1120 1 0 {name=p645 lab=BL7}
C {devices/iopin.sym} 4980 -1120 1 0 {name=p646 lab=BLB7}
C {devices/lab_pin.sym} 5470 -1390 1 1 {name=p647 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5880 -1390 1 1 {name=p648 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5470 -1190 1 1 {name=p649 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5880 -1190 1 1 {name=p650 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5460 -1340 1 1 {name=p651 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5870 -1340 1 1 {name=p652 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5460 -1140 1 1 {name=p653 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5870 -1140 1 1 {name=p654 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 5300 -1200 0 0 {name=x209}
C {sram6t_tr10.sym} 5300 -1400 0 0 {name=x210}
C {sram6t_tr10.sym} 5710 -1400 0 0 {name=x211}
C {sram6t_tr10.sym} 5710 -1200 0 0 {name=x212}
C {devices/lab_pin.sym} 6350 -1390 1 1 {name=p655 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6760 -1390 1 1 {name=p656 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6350 -1190 1 1 {name=p657 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6760 -1190 1 1 {name=p658 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6340 -1340 1 1 {name=p659 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6750 -1340 1 1 {name=p660 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6340 -1140 1 1 {name=p661 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6750 -1140 1 1 {name=p662 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 6180 -1200 0 0 {name=x213}
C {sram6t_tr10.sym} 6180 -1400 0 0 {name=x214}
C {sram6t_tr10.sym} 6590 -1400 0 0 {name=x215}
C {sram6t_tr10.sym} 6590 -1200 0 0 {name=x216}
C {devices/lab_pin.sym} 7270 -1390 1 1 {name=p663 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7680 -1390 1 1 {name=p664 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7270 -1190 1 1 {name=p665 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7680 -1190 1 1 {name=p666 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7260 -1340 1 1 {name=p667 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7670 -1340 1 1 {name=p668 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7260 -1140 1 1 {name=p669 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7670 -1140 1 1 {name=p670 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 7100 -1200 0 0 {name=x217}
C {sram6t_tr10.sym} 7100 -1400 0 0 {name=x218}
C {sram6t_tr10.sym} 7510 -1400 0 0 {name=x219}
C {sram6t_tr10.sym} 7510 -1200 0 0 {name=x220}
C {devices/lab_pin.sym} 8150 -1390 1 1 {name=p671 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8560 -1390 1 1 {name=p672 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8150 -1190 1 1 {name=p673 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8560 -1190 1 1 {name=p674 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8140 -1340 1 1 {name=p675 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8550 -1340 1 1 {name=p676 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8140 -1140 1 1 {name=p677 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8550 -1140 1 1 {name=p678 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 7980 -1200 0 0 {name=x221}
C {sram6t_tr10.sym} 7980 -1400 0 0 {name=x222}
C {sram6t_tr10.sym} 8390 -1400 0 0 {name=x223}
C {sram6t_tr10.sym} 8390 -1200 0 0 {name=x224}
C {devices/iopin.sym} 5480 -1120 1 0 {name=p679 lab=BL8}
C {devices/iopin.sym} 5500 -1120 1 0 {name=p680 lab=BLB8}
C {devices/iopin.sym} 5890 -1120 1 0 {name=p681 lab=BL9}
C {devices/iopin.sym} 5910 -1120 1 0 {name=p682 lab=BLB9}
C {devices/iopin.sym} 6360 -1120 1 0 {name=p683 lab=BL10}
C {devices/iopin.sym} 6380 -1120 1 0 {name=p684 lab=BLB10}
C {devices/iopin.sym} 6770 -1120 1 0 {name=p685 lab=BL11}
C {devices/iopin.sym} 6790 -1120 1 0 {name=p686 lab=BLB11}
C {devices/iopin.sym} 7280 -1120 1 0 {name=p687 lab=BL12}
C {devices/iopin.sym} 7300 -1120 1 0 {name=p688 lab=BLB12}
C {devices/iopin.sym} 7690 -1120 1 0 {name=p689 lab=BL13}
C {devices/iopin.sym} 7710 -1120 1 0 {name=p690 lab=BLB13}
C {devices/iopin.sym} 8160 -1120 1 0 {name=p691 lab=BL14}
C {devices/iopin.sym} 8180 -1120 1 0 {name=p692 lab=BLB14}
C {devices/iopin.sym} 8570 -1120 1 0 {name=p693 lab=BL15}
C {devices/iopin.sym} 8590 -1120 1 0 {name=p694 lab=BLB15}
C {devices/lab_pin.sym} 1870 -900 1 1 {name=p695 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2280 -900 1 1 {name=p696 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1870 -700 1 1 {name=p697 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2280 -700 1 1 {name=p698 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1500 -990 0 0 {name=p699 sig_type=std_logic lab=WL14}
C {devices/lab_pin.sym} 1500 -790 0 0 {name=p700 sig_type=std_logic lab=WL15}
C {devices/lab_pin.sym} 1860 -850 1 1 {name=p701 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2270 -850 1 1 {name=p702 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1860 -650 1 1 {name=p703 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2270 -650 1 1 {name=p704 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 1700 -710 0 0 {name=x225}
C {sram6t_tr10.sym} 1700 -910 0 0 {name=x226}
C {sram6t_tr10.sym} 2110 -910 0 0 {name=x227}
C {sram6t_tr10.sym} 2110 -710 0 0 {name=x228}
C {devices/lab_pin.sym} 2750 -900 1 1 {name=p705 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3160 -900 1 1 {name=p706 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2750 -700 1 1 {name=p707 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3160 -700 1 1 {name=p708 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2740 -850 1 1 {name=p709 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3150 -850 1 1 {name=p710 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2740 -650 1 1 {name=p711 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3150 -650 1 1 {name=p712 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 2580 -710 0 0 {name=x229}
C {sram6t_tr10.sym} 2580 -910 0 0 {name=x230}
C {sram6t_tr10.sym} 2990 -910 0 0 {name=x231}
C {sram6t_tr10.sym} 2990 -710 0 0 {name=x232}
C {devices/lab_pin.sym} 3670 -900 1 1 {name=p713 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4080 -900 1 1 {name=p714 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3670 -700 1 1 {name=p715 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4080 -700 1 1 {name=p716 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3660 -850 1 1 {name=p717 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4070 -850 1 1 {name=p718 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3660 -650 1 1 {name=p719 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4070 -650 1 1 {name=p720 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 3500 -710 0 0 {name=x233}
C {sram6t_tr10.sym} 3500 -910 0 0 {name=x234}
C {sram6t_tr10.sym} 3910 -910 0 0 {name=x235}
C {sram6t_tr10.sym} 3910 -710 0 0 {name=x236}
C {devices/lab_pin.sym} 4550 -900 1 1 {name=p721 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4960 -900 1 1 {name=p722 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4550 -700 1 1 {name=p723 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4960 -700 1 1 {name=p724 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4540 -850 1 1 {name=p725 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4950 -850 1 1 {name=p726 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4540 -650 1 1 {name=p727 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4950 -650 1 1 {name=p728 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 4380 -710 0 0 {name=x237}
C {sram6t_tr10.sym} 4380 -910 0 0 {name=x238}
C {sram6t_tr10.sym} 4790 -910 0 0 {name=x239}
C {sram6t_tr10.sym} 4790 -710 0 0 {name=x240}
C {devices/iopin.sym} 1880 -630 1 0 {name=p729 lab=BL0}
C {devices/iopin.sym} 1900 -630 1 0 {name=p730 lab=BLB0}
C {devices/iopin.sym} 2290 -630 1 0 {name=p731 lab=BL1}
C {devices/iopin.sym} 2310 -630 1 0 {name=p732 lab=BLB1}
C {devices/iopin.sym} 2760 -630 1 0 {name=p733 lab=BL2}
C {devices/iopin.sym} 2780 -630 1 0 {name=p734 lab=BLB2}
C {devices/iopin.sym} 3170 -630 1 0 {name=p735 lab=BL3}
C {devices/iopin.sym} 3190 -630 1 0 {name=p736 lab=BLB3}
C {devices/iopin.sym} 3680 -630 1 0 {name=p737 lab=BL4}
C {devices/iopin.sym} 3700 -630 1 0 {name=p738 lab=BLB4}
C {devices/iopin.sym} 4090 -630 1 0 {name=p739 lab=BL5}
C {devices/iopin.sym} 4110 -630 1 0 {name=p740 lab=BLB5}
C {devices/iopin.sym} 4560 -630 1 0 {name=p741 lab=BL6}
C {devices/iopin.sym} 4580 -630 1 0 {name=p742 lab=BLB6}
C {devices/iopin.sym} 4970 -630 1 0 {name=p743 lab=BL7}
C {devices/iopin.sym} 4990 -630 1 0 {name=p744 lab=BLB7}
C {devices/lab_pin.sym} 5480 -900 1 1 {name=p745 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5890 -900 1 1 {name=p746 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5480 -700 1 1 {name=p747 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5890 -700 1 1 {name=p748 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5470 -850 1 1 {name=p749 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5880 -850 1 1 {name=p750 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5470 -650 1 1 {name=p751 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5880 -650 1 1 {name=p752 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 5310 -710 0 0 {name=x241}
C {sram6t_tr10.sym} 5310 -910 0 0 {name=x242}
C {sram6t_tr10.sym} 5720 -910 0 0 {name=x243}
C {sram6t_tr10.sym} 5720 -710 0 0 {name=x244}
C {devices/lab_pin.sym} 6360 -900 1 1 {name=p753 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6770 -900 1 1 {name=p754 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6360 -700 1 1 {name=p755 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6770 -700 1 1 {name=p756 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6350 -850 1 1 {name=p757 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6760 -850 1 1 {name=p758 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6350 -650 1 1 {name=p759 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6760 -650 1 1 {name=p760 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 6190 -710 0 0 {name=x245}
C {sram6t_tr10.sym} 6190 -910 0 0 {name=x246}
C {sram6t_tr10.sym} 6600 -910 0 0 {name=x247}
C {sram6t_tr10.sym} 6600 -710 0 0 {name=x248}
C {devices/lab_pin.sym} 7280 -900 1 1 {name=p761 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7690 -900 1 1 {name=p762 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7280 -700 1 1 {name=p763 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7690 -700 1 1 {name=p764 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 7270 -850 1 1 {name=p765 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7680 -850 1 1 {name=p766 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7270 -650 1 1 {name=p767 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7680 -650 1 1 {name=p768 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 7110 -710 0 0 {name=x249}
C {sram6t_tr10.sym} 7110 -910 0 0 {name=x250}
C {sram6t_tr10.sym} 7520 -910 0 0 {name=x251}
C {sram6t_tr10.sym} 7520 -710 0 0 {name=x252}
C {devices/lab_pin.sym} 8160 -900 1 1 {name=p769 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8570 -900 1 1 {name=p770 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8160 -700 1 1 {name=p771 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8570 -700 1 1 {name=p772 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 8150 -850 1 1 {name=p773 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8560 -850 1 1 {name=p774 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8150 -650 1 1 {name=p775 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8560 -650 1 1 {name=p776 sig_type=std_logic lab=VSS}
C {sram6t_tr10.sym} 7990 -710 0 0 {name=x253}
C {sram6t_tr10.sym} 7990 -910 0 0 {name=x254}
C {sram6t_tr10.sym} 8400 -910 0 0 {name=x255}
C {sram6t_tr10.sym} 8400 -710 0 0 {name=x256}
C {devices/iopin.sym} 5490 -630 1 0 {name=p777 lab=BL8}
C {devices/iopin.sym} 5510 -630 1 0 {name=p778 lab=BLB8}
C {devices/iopin.sym} 5900 -630 1 0 {name=p779 lab=BL9}
C {devices/iopin.sym} 5920 -630 1 0 {name=p780 lab=BLB9}
C {devices/iopin.sym} 6370 -630 1 0 {name=p781 lab=BL10}
C {devices/iopin.sym} 6390 -630 1 0 {name=p782 lab=BLB10}
C {devices/iopin.sym} 6780 -630 1 0 {name=p783 lab=BL11}
C {devices/iopin.sym} 6800 -630 1 0 {name=p784 lab=BLB11}
C {devices/iopin.sym} 7290 -630 1 0 {name=p785 lab=BL12}
C {devices/iopin.sym} 7310 -630 1 0 {name=p786 lab=BLB12}
C {devices/iopin.sym} 7700 -630 1 0 {name=p787 lab=BL13}
C {devices/iopin.sym} 7720 -630 1 0 {name=p788 lab=BLB13}
C {devices/iopin.sym} 8170 -630 1 0 {name=p789 lab=BL14}
C {devices/iopin.sym} 8190 -630 1 0 {name=p790 lab=BLB14}
C {devices/iopin.sym} 8580 -630 1 0 {name=p791 lab=BL15}
C {devices/iopin.sym} 8600 -630 1 0 {name=p792 lab=BLB15}
C {devices/lab_pin.sym} 1790 -4740 0 0 {name=p793 sig_type=std_logic lab=WL2}
C {devices/lab_pin.sym} 1790 -4690 0 0 {name=p794 sig_type=std_logic lab=WL3}
C {devices/ipin.sym} 1820 -4740 0 1 {name=p795 lab=WL2}
C {devices/ipin.sym} 1820 -4690 0 1 {name=p796 lab=WL3}
C {devices/lab_pin.sym} 1960 -4740 0 0 {name=p797 sig_type=std_logic lab=WL4}
C {devices/lab_pin.sym} 1960 -4690 0 0 {name=p798 sig_type=std_logic lab=WL5}
C {devices/ipin.sym} 1990 -4740 0 1 {name=p799 lab=WL4}
C {devices/ipin.sym} 1990 -4690 0 1 {name=p800 lab=WL5}
C {devices/lab_pin.sym} 2160 -4740 0 0 {name=p801 sig_type=std_logic lab=WL6}
C {devices/lab_pin.sym} 2160 -4690 0 0 {name=p802 sig_type=std_logic lab=WL7}
C {devices/ipin.sym} 2190 -4740 0 1 {name=p803 lab=WL6}
C {devices/ipin.sym} 2190 -4690 0 1 {name=p804 lab=WL7}
C {devices/lab_pin.sym} 1590 -4620 0 0 {name=p809 sig_type=std_logic lab=WL8}
C {devices/lab_pin.sym} 1590 -4570 0 0 {name=p810 sig_type=std_logic lab=WL9}
C {devices/ipin.sym} 1620 -4620 0 1 {name=p811 lab=WL8}
C {devices/ipin.sym} 1620 -4570 0 1 {name=p812 lab=WL9}
C {devices/lab_pin.sym} 1790 -4620 0 0 {name=p813 sig_type=std_logic lab=WL10}
C {devices/lab_pin.sym} 1790 -4570 0 0 {name=p814 sig_type=std_logic lab=WL11}
C {devices/ipin.sym} 1820 -4620 0 1 {name=p815 lab=WL10}
C {devices/ipin.sym} 1820 -4570 0 1 {name=p816 lab=WL11}
C {devices/lab_pin.sym} 1960 -4620 0 0 {name=p817 sig_type=std_logic lab=WL12}
C {devices/lab_pin.sym} 1960 -4570 0 0 {name=p818 sig_type=std_logic lab=WL13}
C {devices/ipin.sym} 1990 -4620 0 1 {name=p819 lab=WL12}
C {devices/ipin.sym} 1990 -4570 0 1 {name=p820 lab=WL13}
C {devices/lab_pin.sym} 2160 -4620 0 0 {name=p821 sig_type=std_logic lab=WL14}
C {devices/lab_pin.sym} 2160 -4570 0 0 {name=p822 sig_type=std_logic lab=WL15}
C {devices/ipin.sym} 2190 -4620 0 1 {name=p823 lab=WL14}
C {devices/ipin.sym} 2190 -4570 0 1 {name=p824 lab=WL15}
